# OrCAD Capture schematic PROC101D_SCH_With_Design_Updates..Notes_V1.0.DSN, sheets 30 to 39 of 40

## Sheets
30 19. TEST AUTOMATION: size C; title: TEST AUTOMATION
31 40. HARDWARE SCHEMATICS: title: HARDWARE SCHEMATICS
32 07. GPIO MAPPING TABLE: title: GPIO  MAPPING TABLE
33 08. I2C TREE: title: I2C TREE
34 06. POWER SEQUENCE: title: POWER SEQUENCE
35 05. POWER FLOW DIAGRAM: title: POWER FLOW DIAGRAM
36 03.BLOCK_DIAGRAM_AM64x_EVM: title: BLOCK DIAGRAM_CP BOARD
37 01. TABLE OF CONTENTS: title: TABLE OF CONTENTS
38 02. REVISION HISTORY: title: REVISION HISTORY
39 17. ICSSG RGMII_2 ETHERNET PHY: size C; title: ICSSG1 RGMII_2 ETHERNET PHY

## Parts
sheet 17. ICSSG RGMII_2 ETHERNET PHY
C89  0.1uF  [CAP0402_0-75]
C99  10uF  [CAP0402_0-75]
C101  1uF  [CAP0402_0-75]
C104  0.1uF  [CAP0402_0-75]
C105  10uF  [CAP0402_0-75]
C106  1uF  [CAP0402_0-75]
C110  1uF  [CAP0402_0-75]
C111  10uF  [CAP0402_0-75]
C112  1uF  [CAP0402_0-75]
C114  1uF  [CAP0402_0-75]
C124  0.1uF  [CAP0402_0-75]
C128  0.1uF  [CAP0402_0-75]
C385  0.1uF  [CAP0402_0-75]
C389  1uF  [CAP0402_0-75]
C392  0.1uF  [CAP0402_0-75]
C394  0.1uF  [CAP0402_0-75]
C395  0.1uF  [CAP0402_0-75]
C397  0.1uF  [CAP0402_0-75]
C401  1uF  [CAP0402_0-75]
FB19  120E  [IND0603_1]
J21  CON_RJ45-28_LPJG17512AONL  [CON_RJ45-28_LPJG17512_S_R_T_25-3]  (sections A,B)
Q14  BSS138LT1G  [SOT23-123_1-2]
Q16  BSS138LT1G  [SOT23-123_1-2]
Q21  BSS138LT1G  [SOT23-123_1-2]
R120  10K  [RES0402_0-5]
R121  10K  [RES0402_0-5]
R126  2.49K_1%  [RES0402_0-5]
R128  2.49K_1%  [RES0402_0-5]
R135  2.49K_1%  [RES0402_0-5]
R324  0E  [RES0402_0-5]
R340  2.49K_1%  [RES0402_0-5]
R341  2.49K_1%  [RES0402_0-5]
R343  0E  [RES0402_0-5]
R347  220E  [RES0402_0-5]
R349  10K_1%  [RES0402_0-5]
R359  2.49K_1%  [RES0402_0-5]
R363  2.49K_1%  [RES0402_0-5]
R366  2.49K_1%  [RES0402_0-5]
R367  10K  [RES0402_0-5]
R368  2.2K  [RES0402_0-5]
R369  10K  [RES0402_0-5]
R370  1.5K  [RES0402_0-5]
R371  10K  [RES0402_0-5]
R380  10K  [RES0402_0-5]
R385  2.49K_1%  [RES0402_0-5]
R386  2.49K_1%  [RES0402_0-5]
R387  2.49K_1%  [RES0402_0-5]
R388  2.49K_1%  [RES0402_0-5]
R562  2.49K_1%  [RES0402_0-5]
R563  2.49K_1%  [RES0402_0-5]
R615  220E  [RES0402_0-5]
R616  220E  [RES0402_0-5]
R617  0E  [RES0402_0-5]
TP69  TP20_SMD  [TP20_SMD]
TP78  TP20_SMD  [TP20_SMD]
U27  TMUX154EDGSR  [MSOP10_19-68_120X120_1-1]
U31  SN74LVC1G08DBVRE4  [SOT23-5]
U80  DP83869HMRGZT  [QFN48_19-68_280X280_1_EP4-2]
sheet 19. TEST AUTOMATION
C161  0.1uF  [CAP0402_0-75]
C181  0.1uF  [CAP0402_0-75]
C469  0.1uF  [CAP0402_0-75]
C472  0.1uF  [CAP0402_0-75]
J38  CON_FLEX_40X1_FH12A-40S-0.5SH  [CON_FLEX40X1_FH12A_S_R_S]
R185  10K  [RES0402_0-5]
R494  4.7K  [RES0402_0-5]
R495  4.7K  [RES0402_0-5]
R521  10K  [RES0402_0-5]
R522  10K  [RES0402_0-5]
R523  10K  [RES0402_0-5]
R524  10K  [RES0402_0-5]
R525  10K  [RES0402_0-5]
R526  10K  [RES0402_0-5]
R542  0E  [RES0402_0-5]
R543  0E  [RES0402_0-5]
R544  0E  [RES0402_0-5]
R545  0E  [RES0402_0-5]
R546  0E  [RES0402_0-5]
R547  0E  [RES0402_0-5]
R548  0E  [RES0402_0-5]
R550  4.7K  [RES0402_0-5]
R551  4.7K  [RES0402_0-5]
TP40  TP20_SMD  [TP20_SMD]
TP41  TP20_SMD  [TP20_SMD]
U51  TCA9617BDGKR  [VSSOP8_25-59_120X120_1-1]
sheet 40. HARDWARE SCHEMATICS
ACC1  SPC02SYAN  [NA]
ACC2  SPC02SYAN  [NA]
ACC3  SPC02SYAN  [NA]
ACC4  MNT-103-BK-G  [NA]
ACC7  SPC02SYAN  [NA]
ACC8  SPC02SYAN  [NA]
ACC10  C19874  [BGASKT441_C19874_1190X1190_11]
ACC11  SZZC019i  [NA]
ACC12  SSZZ027  [NA]
ACC13  AM6442ALV
ACC14  SPC02SYAN  [NA]
ACC15  SPC02SYAN  [NA]
FID1  FID_40X80  [FID_40X80]
FID2  FID_40X80  [FID_40X80]
FID3  FID_40X80  [FID_40X80]
LBL1  THT-103-423-10  [NA]
LBL2  THT-103-423-10  [NA]
LBL3  THT-103-423-10  [NA]
Logo1  Texas Intruments  [TI_Stacked_Overlay_Small]
Logo2  For Evaluation only; not FCC approved for resale  [FCC_disclaimer]
Logo3  WEEE Mark  [TI_Stacked_Overlay_Small]
Logo4  CE Mark  [TI_Stacked_Overlay_Small]
M1  728  [NA]
M2  728  [NA]
M3  728  [NA]
M4  728  [NA]
M5  728  [NA]
M6  728  [NA]
M10  PLAIN WASHER_M3  [NA]
M11  PLAIN WASHER_M3  [NA]
M12  PLAIN WASHER_M3  [NA]
M13  PLAIN WASHER_M3  [NA]
M14  PLAIN WASHER_M3  [NA]
M19  PLAIN WASHER_M3  [NA]
MH1  HEX SPACER_M2.5 X 30  [NA]
MH2  HEX SPACER_M2.5 X 30  [NA]
MH3  HEX SPACER_M2.5 X 30  [NA]
MH4  HEX SPACER_M2.5 X 30  [NA]
MH5  HEX SPACER_M2.5 X 30  [NA]
MH6  HEX SPACER_M2.5 X 30  [NA]
MH13  PAN HEAD_M2.5 X 4  [NA]
MH14  PAN HEAD_M2.5 X 4  [NA]
MH15  PAN HEAD_M2.5 X 4  [NA]
MH16  PAN HEAD_M2.5 X 4  [NA]
MH17  PAN HEAD_M2.5 X 4  [NA]
MH18  PAN HEAD_M2.5 X 4  [NA]
MH19  PAN HEAD_M2.5 X 12  [NA]
MH20  PAN HEAD_M2.5 X 12  [NA]
MH21  PAN HEAD_M2.5 X 12  [NA]
MH22  PAN HEAD_M2.5 X 12  [NA]
MH23  PAN HEAD_M2.5 X 12  [NA]
MH24  PAN HEAD_M2.5 X 12  [NA]
PCB1  PROC101

## Library data of the parts
C89 C104 C124 C128 C161 C181 C385 C392 C394 C395 C397 C469 C472 = CAP: CAP CERAMIC 0.1uF 25V 20% X5R 0402; Alt_Mfr_name: YAGEO AMERICA; Alt_Mfr_part_number: CC0402KRX5R8BB104; Chkd/date: MANIRAJA/170820; Crtd /date: ALVY/170820; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 732-7495-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: WURTH ELECTRONICS; Mfr_part_number: 885012105018; Mistral Part No: 120020080003-R; Package: 0402; Part_type: CAPACITORS\CERAMIC; Project: AM64x_EVM_BRD; RoHS: RoHS; Temperature: -55°C+85°C; Tolerance: 20%; Voltage: 25V; Wattage: NA; Weight: 0.65mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\885012105018.PDF
C99 C105 C111 = CAP: CAP CERAMIC 10uF 10V 20% X5R 0402; Chkd/date: MANIRAJA/300520; Crtd /date: ALVY/260520; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 490-GRM155R61A106ME11DTR-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRM155R61A106ME11D; Mistral Part No: 120013110019-R; Package: 0402; Part_type: CAPACITORS\CERAMIC; Project: QCS610_NANOSOM; RoHS: RoHS; Temperature: -55°C+85°C; Tolerance: 20%; Voltage: 10V; Wattage: NA; Weight: 3.1mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\MURATA-GXX-SER_NOV17.PDF
C101 C106 C110 C112 C114 C389 C401 = CAP: CAP CERAMIC 1uF 10V 20% X5R 0402; Chkd/date: MANIRAJA/210820; Crtd /date: ALVY/190820; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 732-7489-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: WURTH ELECTRONICS; Mfr_part_number: 885012105012; Mistral Part No: 120020080009-R; Package: 0402; Part_type: CAPACITORS\CERAMIC; Project: AM64x_EVM_BRD; RoHS: RoHS; Temperature: -55°C+85°C; Tolerance: 20%; Voltage: 10V; Wattage: NA; Weight: 0.65mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\885012105012.PDF
FB19 = INDUCTOR_FERRITE: IND FERRITE BEAD CHIP 120E 2A 0603; Chkd/date: MANIRAJA/180820; Crtd /date: ALVY/180820; Custom_Duty: 24%; Customs_HS_Code: 85437099; Distributor_name: DIGIKEY; Distributor_part_number: 732-782631141CT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 1.00MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_FILTER_Library.schlib; Mfr_name: WURTH ELECTRONICS; Mfr_part_number: 782631141; Mistral Part No: 130020080015-R; Package: 0603; Part_type: INDUCTOR; Project: AM64x_EVM_BRD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 25%; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\DISCRETES\INDUCTORS\782631141.PDF
J21 = CON_RJ45-28_LPJG17512AONL: CON JACK RJ45 28POS REGISTERED FEMALE RA TH; Chkd/date: MANIRAJA/010817; Crtd /date: MANIRAJA/010817; Custom_Duty: 24%; Customs_HS_Code: 85369090; Distributor_name: NA; Distributor_part_number: NA; Height: 25.30MM; Mfr_name: LINK-PP; Mfr_part_number: LPJG17512AONL; Mistral Part No: 150017080001-R; Package: THRU-HOLE; Part_type: CONNECTOR\JACK; Project: TI_SVB_DUT; RoHS: RoHS; Temperature: 0°C+70°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CONNECTORS\LPJG17512AONL.PDF
Q14 Q16 Q21 = MOSFET_BSS138LT1G: IC MOSFET N-CHANNEL 50V 200mA SOT23-3; Chkd/date: MANIRAJA/250219; Crtd /date: JEBRAN/060416; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: BSS138LT1GOSCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 1.11MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_MOSFET_Library.schlib; Library Ref: MOSFET_BSS138W; Mfr_name: ON SEMICONDUCTOR; Mistral Part No: 142016040001-R; Package: SOT23-3; Part_type: ICS\POWER\MOSFET; Project: LRDE_ABCM; RoHS: RoHS; Temperature: -55°C+150°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 8mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\DISCRETES\TRANSISTORS_FETS\BSS138LT1G.PDF
R120 R121 R185 R367 R369 R371 R380 R521-R526 = RESISTOR: RES 10K 1/16W 5% 0402; Chkd/date: VASANTHA/061216; Crtd /date: MAZHAR/230805; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-10KJRCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0402JR-0710KL; Mistral Part No: 110011060021-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: HSE; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 5%; Voltage: NA; Wattage: 1/16W; Weight: 0.65mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R126 R128 R135 R340 R341 R359 R363 R366 R385-R388 R562 R563 = RESISTOR: RES 2.49K 1/16W 1% 0402; Chkd/date: VASANTHA/270516; Crtd /date: VASANTHA/270516; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-2.49KLRCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0402FR-072K49L; Mistral Part No: 110016050020-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: TMDXCSKCC; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 1%; Voltage: NA; Wattage: 1/16W; Weight: 0.65mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R324 R343 R542-R548 R617 = RESISTOR: RES 0E 1/16W JUMPER 0402; Chkd/date: VASANTHA/201216; Crtd /date: MUDDU/190810; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 541-0.0JCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: VISHAY; Mfr_part_number: CRCW04020000Z0ED; Mistral Part No: 110010080019-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: PB_BUGBASE; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: NA; Voltage: NA; Wattage: 1/16W; Weight: 0.65mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\CRCW0603.PDF
R347 R615 R616 = RESISTOR: RES 220E 1/10W 5% 0402; Chkd/date: VASANTHA/291216; Crtd /date: GEETHA/260406; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: P220JCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: PANASONIC-ECG; Mfr_part_number: ERJ-2GEJ221X; Mistral Part No: 110009030506-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: RED EYE; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 5%; Voltage: NA; Wattage: 1/10W; Weight: 0.8mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\PAN-ERJSER_NOV17.PDF
R349 = RESISTOR: RES 10K 1/10W 1% AUTO 0402; Chkd/date: MANIRAJA/191020; Crtd /date: ALVY/191020; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: MCS0402-10.0K-MFCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.37MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: VISHAY; Mfr_part_number: MCS0402MC1002FE000; Mistral Part No: 110020100039-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: MCX_80MHz_ADC_DRIVER; RoHS: RoHS; Temperature: -55°C+175°C; Tolerance: 1%; Voltage: NA; Wattage: 1/10W; Weight: 0.65mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\MCTXXXXM-SER.PDF
R368 = RESISTOR: RES 2.2K 1/16W 5% 0402; Chkd/date: VASANTHA/061216; Crtd /date: BAVISH/021210; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-2.2KJRCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0402JR-072K2L; Mistral Part No: 110010120018-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: TE4; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 5%; Voltage: NA; Wattage: 1/16W; Weight: 0.65mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R370 = RESISTOR: RES 1.5K 1/16W 5% 0402; Chkd/date: MANIRAJA/310718; Crtd /date: BAVISH/021210; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-1.5KJRCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0402JR-071K5L; Mistral Part No: 110010120012-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: TE4; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 5%; Voltage: NA; Wattage: 1/16W; Weight: 0.65mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
TP40 TP41 TP69 TP78 = TESTPOINT: TESTPOINT CIR 20 SMD; Chkd/date: SHREESHAIL/171006; Crtd /date: MAZHAR/171006; Custom_Duty: NA; Customs_HS_Code: NA; Distributor_name: NA; Distributor_part_number: NA; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: NA; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; MECHANICAL 3D STEP FILE: NA; Mfr_name: LOCAL; Mistral Part No: NA; Package: SMD; Project: BT MODULE_CSRBC04; RoHS: NA; Temperature: NA; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: NA
U27 = TMUX154EDGSR_VSSOP10: IC ESD PROTECTED 2-CH 2:1 SWITCH WITH POWERED-OFF PROTECTION VSSOP10; Chkd/date: MANIRAJA/040918; Crtd /date: MANIRAJA/040918; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: 296-48347-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 1.10MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_ANALOG-APPLICATION_Library.schlib; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 140118090001-R; Package: VSSOP10; Part_type: ICS\ANALOG\SWITCH; Project: DLRL_DFP_ATRUC CARD; RoHS: RoHS; Temperature: -40°C+85°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\ANALOG\TMUX154EXXX.PDF
U31 = SN74LVC1G08DBVRE4_SOT23-5: IC SINGLE 2-INPUT POSITIVE AND GATE SOT23-5; Chkd/date: SUHAS/221010; Crtd /date: USMAN/151008; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: SN74LVC1G08DBVRE4-ND; Height: 1.45MM; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 141009060026-R; Part_type: ICS\DIGITAL\GATES; Project: KHAN_MAIN; RoHS: Sb/ Br FREE; Temperature: -40°C+85°C; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\DIGITAL\GATES\SN74LVC1G08.PDF
U80 = DP83869HM_VQFN48: IC ETHERNET TRANSCEIVER 10/100/1000 WITH COPPER AND FIBRE INTERFACE VQFN48; Chkd/date: MANIRAJA/060519; Crtd /date: ALVY/060519; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: 296-53377-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 1.00MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_TELECOM_Library.schlib; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 143019050002-R; Package: VQFN48; Part_type: ICS\TELECOM\TRANSCEIVER; Project: J7ES_ENET_DP83869HM_EXP; RoHS: RoHS; Temperature: -40°C+125°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\TELECOM\DP83869HM.PDF
J38 = CON_FLEX_40X1_FH12A-40S-0.5SH: CON FPC 40X1 0.50MM PITCH RT TOP SMD; Chkd/date: SHREESHAIL/201106; Crtd /date: MAZHAR/171106; Custom_Duty: 24%; Customs_HS_Code: 85369090; Distributor_name: DIGIKEY; Distributor_part_number: HFK40CT-ND; Height: 2.00MM; Mfr_name: HIROSE ELECTRIC EUROPE; Mfr_part_number: FH12A-40S-0.5SH(55); Mistral Part No: 150009030176-R; Package: SMD; Part_type: CONNECTOR\FPC; Project: PMP LCD BOARD; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CONNECTORS\FH12SERIES.PDF
R494 R495 R550 R551 = RESISTOR: RES 4.7K 1/16W 5% 0402; Chkd/date: VASANTHA/130516; Crtd /date: VASANTHA/130516; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-4.7KJRCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0402JR-074K7L; Mistral Part No: 110011060001-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: TMDXCSK368; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 5%; Voltage: NA; Wattage: 1/16W; Weight: 0.65mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
U51 = TCA9617BDGKR_VSSOP8: IC FM+I2C BUS REPEATER LEVEL TRANSLATOR VSSOP8; Chkd/date: MANIRAJA/131017; Crtd /date: MANIRAJA/131017; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: 296-40579-1-ND; Height: 1.10MM; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 141017100010-R; Package: VSSOP8; Part_type: ICS\INTERFACE\LEVEL TRANSLATOR; Project: TI_MAXIE_CPB; RoHS: RoHS; Temperature: -40°C+85°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\INTERFACE\TCA9617B.PDF
ACC1-ACC3 ACC7 ACC8 ACC14 ACC15 = ACCESSORY: ACCESSORIE JUMPER SHORTING GOLD FLASH; Chkd/date: SUHAS\211010; Crtd /date: USMAN/301208; Distributor_name: DIGIKEY; Distributor_part_number: S9001-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_MECHANICAL_Library.schlib; Mfr_name: SULLINS CONNECTOR; Mistral Part No: 160009030153-R; Part_type: ACCESSORIES; Project: SMART VIEW_NVR; RoHS: RoHS; Temperature: -55°C+105°C; Datasheet: Y:\MIS_DATABASE\DATASHEETS\MISC\MODULES\SPC02SYAN.PDF
ACC4 = ACCESSORY: ACCESSORIE CONNECTOR SHUNT 2X3 POS EDGE MOUNT SOCKET STRIP; Chkd/date: MANIRAJA/141117; Crtd /date: MANIRAJA/141117; Distributor_name: DIGIKEY; Distributor_part_number: SAM10620-ND; Mfr_name: SAMTEC; Mistral Part No: 160017110050-R; Part_type: ACCESSORIES; Project: TI_MAXIE_CPB; RoHS: RoHS; Temperature: -55°C+125°C; Datasheet: Y:\MIS_DATABASE\DATASHEETS\MISC\ACCESSORIES\SAMTEC-MNT-SER.PDF
ACC10 = ACCESSORY: ACCESSORIE BGA SOCKET AM64x MICROPROCESSOR BGA441; Chkd/date: MANIRAJA/220620; Crtd /date: ALVY/220620; Custom_Duty: NA; Customs_HS_Code: NA; Distributor_name: NA; Distributor_part_number: NA; Footprint Path: NA; Height: 10.93MM; Library Path: NA; Mfr_name: IRONWOOD ELECTRONICS; Mistral Part No: 160020060058; Package: BGA441; Part_type: ACCESSORIES; Project: AM64x-GP_EVM BRD; RoHS: NA; Temperature: -55°C+160°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 39530mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\MISC\ACCESSORIES\C19874_MAY20.PDF
ACC11 = ACCESSORY: ACCESSORIE TI EVM FLYERS STANDARD TERMS AND CONDITIONS; Chkd/date: MANIRAJA/221020; Crtd /date: ALVY/211020; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 160020100056; Part_type: ACCESSORIES; Project: AM64x-IO LINK BRD
ACC12 = ACCESSORY: ACCESSORIE TI EVM FLYERS STANDARD WARRANTY NOTICE-BLACK AND WHITE; Chkd/date: MANIRAJA/221020; Crtd /date: ALVY/211020; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 160020100057; Part_type: ACCESSORIES; Project: AM64x-IO LINK BRD
ACC13 = ACCESSORY: IC AM64 SoC MICROPROCESSOR BGA441; Custom_Duty: NA; Customs_HS_Code: NA; Distributor_name: NA; Distributor_part_number: NA; Footprint Path: NA; Height: 2.57MM; Library Path: NA; Mfr_name: TEXAS INSTRUMENTS; Mfr_part_number: AM6442ASFGGAALV; Mistral Part No: 141220040002; Package: BGA441; Part_type: ACCESSORIES; Project: AM64x-GP_EVM BRD; RoHS: NA; Temperature: -55°C+160°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 39530mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\MISC\ACCESSORIES\C19874_MAY20.PDF
FID1-FID3 = Fiducial
LBL1-LBL3 = ACCESSORY_THT-3-423-10: ACCESSORIE 1 WORKHORSE POLYSTER LABLE 0.25" X 1"; Chkd/date: MANIRAJA/270218; Crtd /date: ALVY/260218; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_MECHANICAL_Library.schlib; Mfr_name: BRADY; Mistral Part No: 160018020185; Part_type: ACCESSORIES; Project: TI_MAXIE_CPB
Logo1 Logo3 Logo4 = TI_Logo
Logo2 = FCC_disclaimer
M1-M6 = ACCESSORY: ACCESSORIE RECESSED BUMPER 19.05MM DIA; Chkd/date: MANIRAJA/110718; Crtd /date: MANIRAJA/110718; Distributor_name: DIGIKEY; Distributor_part_number: 36-728-ND; Mfr_name: KEYSTONE; Mistral Part No: 160018070042-R; Part_type: ACCESSORIES; Project: TI_MAXIE_CPB; RoHS: RoHS; Weight: 2042mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\MISC\ACCESSORIES\728.PDF
M10-M14 M19 = WASHER_PLAIN: PLAIN WASHER FOR M3 SS-316; Chkd/date: MANIRAJA/190218; Crtd /date: MANIRAJA/190218; Distributor_name: DIGIKEY; Distributor_part_number: 36-4692-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_MECHANICAL_Library.schlib; Mfr_name: KEYSTONE; Mfr_part_number: 4692; Mistral Part No: 160018020078-R; Package: SS; Part_type: MECHANICAL\WASHERS; Project: TI_MAXIE_CPB; RoHS: RoHS; Datasheet: Y:\MIS_DATABASE\DATASHEETS\MISC\MECHANICAL\4692.PDF
MH1-MH6 = HEX_SPACER_FF: HEX SPACER FEMALE TO FEMALE M2.5 X 30MM; Chkd/date: MANIRAJA/190218; Crtd /date: MANIRAJA/190218; Distributor_name: DIGIKEY; Distributor_part_number: 732-10626-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 30.00MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_MECHANICAL_Library.schlib; Mfr_name: WURTH ELECTRONICS; Mfr_part_number: 970300151; Mistral Part No: 160018020071-R; Package: SS; Part_type: MECHANICAL\SPACER; Project: TI_MAXIE_CPB; RoHS: RoHS; Datasheet: Y:\MIS_DATABASE\DATASHEETS\MISC\MECHANICAL\970XXX1.PDF
MH13-MH18 = SCREW_PAN: PHILLIPS PAN HEAD SCREW - M2.5 X 4 SS-316; Chkd/date: MANIRAJA/190218; Crtd /date: MANIRAJA/190218; Distributor_name: DIGIKEY; Distributor_part_number: 36-29300-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 4.00MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_MECHANICAL_Library.schlib; Mfr_name: KEYSTONE; Mfr_part_number: 29300; Mistral Part No: 160018020076-R; Package: SS; Part_type: MECHANICAL\SCREWS; Project: TI_MAXIE_CPB; RoHS: RoHS; Datasheet: Y:\MIS_DATABASE\DATASHEETS\MISC\MECHANICAL\29300.PDF
MH19-MH24 = SCREW_PAN: PHILLIPS PAN HEAD SCREW - M2.5 X 12; Chkd/date: MANIRAJA/110718; Crtd /date: MANIRAJA/110718; Distributor_name: DIGIKEY; Distributor_part_number: 36-29304-ND; Height: 12.00MM; Mfr_name: KEYSTONE; Mfr_part_number: 29304; Mistral Part No: 160018070043-R; Part_type: ACCESSORIES; Project: TI_MAXIE_CPB; RoHS: RoHS; Datasheet: Y:\MIS_DATABASE\DATASHEETS\MISC\MECHANICAL\29304.PDF
PCB1 = PCB: AM64x EVM Bare PCB; Mfr_part_number: PROC101D

## Nets
DGND: C89.2 C99.2 C101.2 C104.2 C105.2 C106.2 C110.2 C111.2 C112.2 C114.2 C124.2 C128.2 C161.2 C181.2 C385.2 C389.2 C392.2 C394.2 C395.2 C397.2 C401.2 C469.2 C472.2 J21.B10(GND) J38.7 J38.16 J38.25 J38.34 J38.40 J38.41 J38.42 Q14.2(S) Q16.2(S) Q21.2(S) R120.2 R121.2 R135.2 R341.2 R349.1 R359.2 R363.2 R367.2 R371.2 R385.2 R386.2 R563.2 U27.5(GND) U31.3(GND) U51.4(GND) U80.49(GND) ; also on sheet 2 3 4 5 6 7 8 9 10 11 12 13 14 15 16 17 18 19 20 21 22 23 24 25 26 27 28 29 40
VCC3V3_TA: C181.1 C469.1 C472.1 J38.1 J38.2 J38.3 R185.2 R494.1 R495.1 R521.2 R522.2 R523.2 R524.2 R525.2 R526.2 R550.1 R551.1 U51.1(VCCA) ; also on sheet 16 17 29
VCC_3V3_SYS: C89.1 C99.1 C101.1 C104.1 C128.1 C161.1 C385.1 C389.1 FB19.1 R126.1 R128.1 R340.1 R347.1 R366.1 R368.2 R369.1 R370.2 R380.2 R387.1 R388.1 R562.1 R615.2 R616.2 U27.10(VCC) U31.5(VCC) U51.8(VCCB) U80.18(VDDIO) U80.30(VDDIO) ; also on sheet 2 5 6 7 8 10 11 12 13 14 15 16 17 18 19 20 21 23 24 25 26 27 29 40
VDD_1V1: C105.1 C110.1 C112.1 C124.1 C394.1 C395.1 C401.1 U80.6(VDDA1P1) U80.31(VDD1P1) U80.39(VDD1P1) ; also on sheet 16 40
VDD_2V5: C106.1 C111.1 C114.1 C392.1 C397.1 U80.3(VDDA2P5) U80.9(VDDA2P5) ; also on sheet 2 16 40
BOOTMODE_I2C_SCL: J38.37 R550.2 ; also on sheet 29
BOOTMODE_I2C_SDA: J38.39 R551.2 ; also on sheet 29
CPSW_RGMII1_MDC: U27.7(B1) ; also on sheet 2 18
CPSW_RGMII1_MDIO: U27.3(A1) ; also on sheet 2 18
GPIO_RGMII2_RST: R371.1 R380.1 U31.1(A) ; also on sheet 13
PORz_OUT: U31.2(B) ; also on sheet 2 12 24 29 40
PRG1_ETH2_D0M: J21.B2(TD1-_2) U80.2(TD_M_A)
PRG1_ETH2_D0P: J21.B1(TD1+_2) U80.1(TD_P_A)
PRG1_ETH2_D1M: J21.B4(TD2-_2) U80.5(TD_M_B)
PRG1_ETH2_D1P: J21.B3(TD2+_2) U80.4(TD_P_B)
PRG1_ETH2_D2M: J21.B6(TD3-_2) U80.8(TD_M_C)
PRG1_ETH2_D2P: J21.B5(TD3+_2) U80.7(TD_P_C)
PRG1_ETH2_D3M: J21.B8(TD4-_2) U80.11(TD_M_D)
PRG1_ETH2_D3P: J21.B7(TD4+_2) U80.10(TD_P_D)
PRG1_ETH2_GPIO_1: R340.2 R341.1 R617.2 U80.22(JTAG_TDO/GPIO_1)
PRG1_ETH2_LED1: J21.B11 Q14.3(D)
PRG1_ETH2_LED2: J21.B14 Q21.3(D) R616.1
PRG1_ETH2_LED3: J21.B13 Q16.3(D) R615.1
PRG1_ETH2_LED_1000/RX_ER: R343.2 R386.1 R388.2 U80.46(LED_1/RX_ER) ; also on sheet 18
PRG1_ETH2_LED_ACT: R324.1 R385.1 R387.2 U80.45(LED_2/GPIO_0)
PRG1_ETH2_LED_LINK: R562.2 R563.1 U80.47(LED_0) ; also on sheet 18
PRG1_MDIO_MDC: U27.8(B0) ; also on sheet 18 40
PRG1_MDIO_MDIO: U27.2(A0) ; also on sheet 18 40
PRG1_RGMII2_ETH2_CLK: U80.20(XI) ; also on sheet 11
PRG1_RGMII2_ETH2_CLK_OUT: TP78.1(TP) U80.40(CLK_OUT)
PRG1_RGMII2_ETH2_RBIAS: R349.2 U80.12(RBIAS)
PRG1_RGMII2_FET_ENn: R121.1 U27.9(~{EN})
PRG1_RGMII2_FET_SEL: R120.1 U27.1(SEL) ; also on sheet 13
PRG1_RGMII2_MDC: R369.2 U27.6(B) U80.42(MDC)
PRG1_RGMII2_MDIO: R370.1 U27.4(A) U80.41(MDIO)
PRG1_RGMII2_RD0: R126.2 R359.1 U80.33(RX_D0) ; also on sheet 18
PRG1_RGMII2_RD1: R128.2 R363.1 U80.34(RX_D1) ; also on sheet 18
PRG1_RGMII2_RD2: U80.35(RX_D2) ; also on sheet 18
PRG1_RGMII2_RD3: U80.36(RX_D3) ; also on sheet 18
PRG1_RGMII2_RESETn: R367.1 U31.4(Y) U80.43(RESET_N)
PRG1_RGMII2_RX_CTL: R135.1 R366.2 U80.38(RX_CTRL/RX_DV) ; also on sheet 18
PRG1_RGMII2_RXC: U80.32(RX_CLK) ; also on sheet 18
PRG1_RGMII2_TD0: U80.28(TX_D0) ; also on sheet 18
PRG1_RGMII2_TD1: U80.27(TX_D1) ; also on sheet 18
PRG1_RGMII2_TD2: U80.26(TX_D2) ; also on sheet 18
PRG1_RGMII2_TD3: U80.25(TX_D3) ; also on sheet 18
PRG1_RGMII2_TX_CTL: U80.37(TX_CTRL/TX_EN) ; also on sheet 18
PRG1_RGMII2_TXC: U80.29(GTX_CLK/TX_CLK) ; also on sheet 18
PRG1_RGMII_INTn: R368.1 U80.44(INT_N/PWDN_N) ; also on sheet 2 12 40
PRG_EARTH: J21.SH3 J21.SH4 ; also on sheet 40
SoC_I2C1_SCL: U51.7(SCLB) ; also on sheet 5 6 7 10 11 13 14
SoC_I2C1_SDA: U51.6(SDAB) ; also on sheet 5 6 7 10 11 13 14
SoC_I2C1_TA_SCL: J38.36 R495.2 U51.2(SCLA)
SoC_I2C1_TA_SDA: J38.38 R494.2 U51.3(SDAA)
TEST_GPIO1: R523.1 R545.1 ; also on sheet 25
TEST_GPIO2: R524.1 R546.1 ; also on sheet 13
TEST_GPIO3: R525.1 R547.1 TP41.1(TP) ; also on sheet 29
TEST_GPIO4: R526.1 R548.1 TP40.1(TP) ; also on sheet 29
TEST_PORZn: R521.1 R543.1 ; also on sheet 25
TEST_POWERDOWN: R542.1 ; also on sheet 17
TEST_WARMRESETn: R522.1 R544.1 ; also on sheet 25
N15365714: J38.27 R543.2
N15365947: J38.30 R545.2
N15366015: J38.31 R546.2
N15366091: J38.32 R547.2
N17211229: J38.33 R548.2
N17546132: J38.26 R542.2
N17546158: J38.28 R544.2
N18117332: Q14.1(G) R324.2
N18117389: Q16.1(G) R343.1
N24754956: TP69.1(TP) U80.13(VDDA1P8_1) U80.48(VDDA1P8_2)
N26442461: R185.1 U51.5(EN)
N27217693: FB19.2 J21.B9(VCC)
N27218087: J21.B12 R347.2
N28854850: Q21.1(G) R617.1

Not connected (* = marked no-connect by the designer): J38 4* 5* 6* 8* 9* 10* 11* 12* 13* 14* 15* 17* 18* 19* 20* 21* 22* 23* 24* 29* 35*; U80 14(SON)* 15(SOP)* 16(SIP)* 17(SIN)* 19(XO)* 21(JTAG_CLK/TX_ER)* 23(JTAG_TMS)* 24(JTAG_TDI/SD)*

## Notes on the sheets
sheet 30
- TEST AUTOMATION
- D-Note :-
  Refer SK-AM62P-LP
  implementation for the latest
  updates
- 40-PIN AUTOMATION HEADER
- D-Note :-
  Processor IOs connected to TEST
  AUTOMATION CONNECTOR are not fail-safe.
  No external input shall be applied when
  Starter Kit/EVM is not powered-up.
- TEST AUTOMATION  GPIO MAPPING
- Internal/
  External
  PU/PD states
- Direction WRT CTRL
- SIGNAL NAME
- DESCRIPTION
- TEST_POWERDOWN
  TEST_PORZn
  TEST_WARMRESETn
  TEST_GPIO1
  TEST_GPIO2
  TEST_GPIO3
  TEST_GPIO4
- Used to Power down the OVP Circuit
  Used to  Reset the SoC PORz
  Used to Reset the SoC Warmreset
  Used to Generate the interrupt on
  GPIO0_13_INTn Pin
  Connected to I/O Expander to Communicate
  with SoC
  Used to Enable the BOOTMODE Buffer
  Used to Reset the Bootmode IO Expander
- OUTPUT
  OUTPUT
  OUTPUT
  OUTPUT
  OUTPUT
  OUTPUT
  OUTPUT
- External Pullup
  External Pullup
  External Pullup
  External Pullup
  External Pullup
  External Pullup
  External Pullup
- Off Page Connections
- To Processor
- To Bootmode
  Buffer
- To Debounce Ckt
- To High Side SW
- To Debounce Ckt
- To Debounce Ckt
- To IO Expander
- To EN Boot Mode Buffer
- To RST Boot Mode Buffer
sheet 31
- MOUNTING HARDWARE
- R-Note :-
  Refer STRAP CONFIGURATION OF ETHERNET PHYS page  of the
  SK schematics
- SCREWS
- JUMPERs
- STANDOFFs
- ASSEMBLY NOTES
- 1. All MSL components should be baked as per JEDEC
  standard.
  2. PCB should be baked at 120 degree for 8 hours.
  3. Board assembly must comply with workmanship standards.
  IPC-A-610 Class 2, unless otherwise specified.
  4. These assemblies are ESD sensitive, ESD precautions
  shall be observed.
  5. These assemblies must be clean and free from flux and
  all contaminants. Use of no clean flux is not acceptable.
  6. Provide serial numbers to the assembled boards for
  identification.
  7. The assembled board are wrapped in ESD Covers(individual)
  and
  packed securely before shipment.
- WASHER's
- FIDUCIALS
- RUBBER FEET
- TI EVM FLYERS
- Socket & Processor as Accessories
- BARE PCB
- LABELS
- LOGOs
- ORDERABLE PART NO
- Texas Intruments
- For Evaluation only; not FCC approved for resale
- WEEE Mark
- CE Mark
- Board Serial No.
- Orderable part number
- Variant
- Label Text
- 001
- TMDS64GPEVM
- Assembly Revision
- 002
- TMDS243GPEVM
- 003
- TMDS64HSEVM
- 004
- TMDS64EVM
- 005
- TMDS243EVM
sheet 32
- GPIO  MAPPING TABLE
sheet 33
- I2C TREE
sheet 34
- POWER SEQUENCE
sheet 35
- POWER FLOW DIAGRAM
sheet 36
- BLOCK DIAGRAM_AM64x_EVM
sheet 37
- AM64x/AM243x  EVM BOARD
- PROC101D
- TABLE OF CONTENTS
- Revision Number
- PAGE
- CONTENTS
- PAGE
- CONTENTS
- REV
- D
- 01
- TABLE OF CONTENTS
- 21
- SOC SUPPLY RAILS -  CURRENT MONITORING
- VER
- 1.3
- 02
- REVISION HISTORY
- 22
- XDS110 DEBUGGER AND POWER
- 03
- BLOCK DIAGRAM AM64x EVM BOARD
- 23
- SOC JTAG INTERFACE AND JTAG BUFFERS
- 04
- BLOCK DIAGRAM - XDS110 DEBUGGER
- 24
- MIPI 60 PIN CONNECTOR, JTAG 20 PIN cTI CONNECTOR AND BUFFERS
- 05
- POWER ARCHITECTURE
- 25
- SOC USB, USB 2.0 INTERFACE AND POWER SWITCH
- 06
- POWER SEQUENCE
- 26
- FT4232 UART TO USB BRIDGE
- 07
- GPIO MAPPING TABLE
- 27
- SOC (ICSSG) PRG0 & PRG1, HSE BOARD CONNECTOR
- 08
- I2C TREE
- 28
- SOC GPMC & GPMC TO FSI & HSE CONNECTOR
- 09
- SOC SUPPLY RAILS AND POWER SUPPLIES
- 29
- SOC PERIPHERALS, CAN TRANSCEIVER, CAN TO HSE AND DISPLAY INTERFACE
- 10
- CAPS FOR SOC POWER SUPPLIES
- 30
- SOC PCIe INTERFACE, PCIe CONNECTOR AND  RESET
- 11
- SOC VSS
- 31
- EXTERNAL LVCMOS CLOCK (OSCILLATOR), SOC, EPHY & PCIe CLOCK
- 12
- SOC DDRSS AND DDR4 MEMORY INTERFACE
- 32
- INDUSTRIAL ETHERNET COMMUNICATION LEDS
- 13
- SOC MMC0..1 INTERFACE, eMMC FLASH AND SD CARD INTERFACE
- 33
- IO EXPANDER & TEST HEADER
- 14
- SOC OSPI/QSPI INTERFACE AND OSPI FLASH
- 34
- MCU GENERAL & SAFETY CONNECTOR PLUS SOC RESET
- 15
- BOARD ID EEPROM, BOARD PRESENCE & DIGITAL TEMP SENSOR
- 35
- SOC PB RESET , DEBOUNCE LOGIC,  VOLTAGE SUPERVISOR
- 16
- CPSW3G RGMII_1 ETHERNET PHY AND FET SWITCH
- 36
- MAIN 12 V DC INPUT AND POWER GOOD INDICATION LEDS
- 17
- ICSSG RGMII_2 - ETHERNET PHY AND MDIO FET SWITCH
- 37
- DUAL OUTPUT BUCK (3.3V,5V) AND PRE_REG 3.3V SUPPLY
- 18
- ICSSG RGMII_1 - ETHERNET PHY
- 38
- SOC POWER SUPPLIES
- 19
- TEST AUTOMATION - CONNECTOR AND I2C BUS REPEATER
- 39
- PERIPHERAL POWER SUPPLIES
- 20
- BOOT MODE CONFIGURATION BUFFERS, RESISTOR DIVIDERS AND DIP SWITCHES
- 40
- ASSEMBLY NOTES AND MOUNTING HARDWARE
- D-Note:-
- SK/EVM is a device evaluation board or platform. The SK/EVM is not a reference design. In some cases the EVM implementation may deviate from the
  optimum solution to provide a better customer experience or provide flexibility for customers to be able to validate the SOC functionality. TI
  expects and recommends customers to carefully review and follow all requirements defined in the datasheet, silicon errata, and TRM when designing
  their custom board. The information found in the datasheet should always take precedence over the SK/EVM implementation.
- R-Note:-
- * Verify the DNI components configuration  with respect to the EVM schematics (Use PDF) after completion of board design before board assembly.
  * A standard 5% tolerance resistor can be used for most of the series and parallel pull resistor.
  * Be sure to read through all the D-Notes (Design notes), R-Notes (Review notes) and CAD notes during board design and before start of board build.
  (Refer  FAQs listed for additional details)
- KEY LINKS TO COLLATERALS
- Hardware Design Guide :
- https://www.ti.com/lit/an/sprad67a/sprad67a.pdf
- Schematic Design and Review Checklist :
- https://www.ti.com/lit/an/spracu5c/spracu5c.pdf
- DDR Board Design and Layout Guidelines :
- https://www.ti.com/lit/an/spracu1a/spracu1a.pdf
- PMIC Power Solutions application note - > Powering the AM64x with the TPS65220 or TPS65219 PMIC
- https://www.ti.com/lit/pdf/slvafe9
- Using LP8733xx and TPS65218xx PMICs to Power AM64x and AM243x Sitara Processors
- https://www.ti.com/lit/pdf/slda059
- EVM/SKs (Starter Kits) for reference :
- TMDS64EVM, SK-AM64B
sheet 38
- REVISION HISTORY
- VER #
- DATE
- DESCRIPTION OF CHANGES
- AUTHOR
- REVIEWED  BY
- APPROVED  BY
- 0.1
- 11th MARCH 2022
- Drafted from "PROC101B_SCH" document.
- Mistral Design Team
- AJIT MB
- AJIT MB
- Removed Voltage Monitor circuit & added RC Delay Circuit for power down
  sequence requirement
  Fixed Power down sequence issue seen on AM243x REV B
- 0.2
- 11th MARCH 2022
- Mistral Design Team
- AJIT MB
- AJIT MB
- 0.3
- 11th MARCH 2022
- Updated schematics to support PG2 Silicon
- Mistral Design Team
- AJIT MB
- AJIT MB
- 30th MARCH 2022
- Baselined and Released
- Mistral Design Team
- AJIT MB
- AJIT MB
- 1.0
- Updated SoC Part Number and OPN Details
- 1.1
- 5th AUG 2022
- Mistral Design Team
- AJIT MB
- AJIT MB
- Updated SoC Symbol for Reserved pins
- Reduced the switching frequency of U30 to 440 Khz for compliance testing (R.E)
- 1.2
- 27 NOV 2023
- Resized the Inductors (L5 & L6), Capacitors (C69, C71, C81 & C82) for the change in
  SW frequency of U30
- Mistral Design Team
- AJIT MB
- AJIT MB
- Updated SoC Part Number, Enabled Voltage ratings for all the capacitors and added
  Design Review notes
- Moved to DNI : R67, R444, R65, C184, C262, C133, C134, Y1
- 1.3
- 12 JUNE 2024
- Moved to Mount : R66, R193, R479, R480, R483, R484, R485, R646, R181, R176, R169,
                            R172, R173, R180, R179, R178, R240, R367, R102
- Mistral Design Team
- C148 4.7uF changed to 1uF; C149 1uF changed to 4.7uF; C243 1uF changed to 2.2uF.
  R404 , R389-22E_1% changed to 0E ; R405-10K changed to 10K,1%; R167-100K
  changed to 10K; R428-3.48K_0.1% changed to 3.48K_1%; R427- 16.5K_0.1% changed
  to 16.5K_1%; R431, R576 - 10K_1% changed to Std 10K; R696- 1K_1% changed to Std
  1K; R157-10E_1% changed to 0E; R70,R349,R110 - 11K_1% changed to 10K_1%.
- LINKS TO KEY FAQs
- https://e2e.ti.com/support/processors-group/processors/f/processors-forum/1185502/faq-am6442-am6441-am6422-am6421-am6412-am6411-custom-board-
  hardware-design-collaterals-to-get-started
- https://e2e.ti.com/support/processors-group/processors/f/processors-forum/1285107/faq-am64x-am62x-am62ax-am62px-custom-board-hardware-design---
  collaterals-for-reference-during-schematic-design-and-schematics-review
- https://e2e.ti.com/support/processors-group/processors/f/processors-forum/1337853/faq-am6442--am6441-am6422-am6421-am6412-am6411-custom-board-
  hardware-design---guidelines-for-reuse-of-tmds64evm-schematics
- https://e2e.ti.com/support/processors-group/processors/f/processors-forum/1274160/faq-am6442-am6441-am6422-am6421-am6412-am6411-custom-board-
  hardware-design---faqs-related-to-processor-collaterals-functioning-peripherals-interface-and-evm-starter-kit
sheet 39
- D-Note :-
  The caps and values used
  are as per the EPHY data
  sheet recommendations
- ICSSG RGMII 2 - ETHERNET PHY
- Dual RJ45 CON With Integrated Magnetics
- Decaps
- R-Note :-
  Ferrite is DNI
- D-Note :-
  VDDA1P8
  These are LDO outputs
  Do not short. Add
  individual TPs for
  testing
- D-Note :-
  Verify the power
  sequence requirements
  for Two-Supply
  Configuration and
  Three-Supply
  Configuration
- D-Note :-
  Add 10 nF cap for
  each supply rail
  Refer EPHY data
  sheet
- STRAPPING RESISTORS
- D-Note :-
  Add a parallel 22 pF cap
  These changes are for
  Ethernet compliance test
  performance improvement
- D-Note :-
  Refer to DP83867ERGZ-R-EVM when using LAN Discrete
  Transformer Module and RJ45 connector
- PRG1 (ICSSG) ETH2 RESET
- D-Note :-
  ANDing logic additionally performs level
  translation
  Verify the Reset IO level compatibility
  before optimizing the reset ANDing logic.
  IO level mismatch could cause supply
  leakage and affect SOC operation
- D-Note :-
  Add an isolation resistor (0R)
  to SoC GPIO for debug and
  testing
- PHY ADDRESS = 00011
- Auto-negotiation, 10/100/1000 advertised, Auto-MDI-X
- RGMII to Copper (1000BaseT/100Base-TX/10Base-Te)
- Off Page Connections
- PRG1 MDC/MDIO FET SWITCH
- To Processor
- PRG1_ETHERNET - 2 SPEED & ACTIVITY  LED 's DRIVERS
- From Processor
- From CPSW SW
- From IO Expander
- TMUX154EDGSR Truth Table
- From Clock Buffer
- SEL
- EN
- FUNCTION
- X
- H
- Disconnet
- A = A0
  B = B0
- L
- L
- A = A1
  B = B1
- H
- L
