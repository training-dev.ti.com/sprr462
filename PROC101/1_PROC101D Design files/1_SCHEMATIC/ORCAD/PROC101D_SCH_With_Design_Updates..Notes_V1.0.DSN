# OrCAD Capture schematic PROC101D_SCH_With_Design_Updates..Notes_V1.0.DSN, sheets 23 to 24 of 40

## Sheets
23 26.FT4232 UART TO USB BRIDGE: size C; title: FT4232 UART TO USB BRIDGE
24 13.eMMC & SD CARD INTERFACE: size C; title: eMMC FLASH_SDCARD INTERFACE

## Parts
sheet 13.eMMC & SD CARD INTERFACE
C148  1uF  [CAP0402_0-75]
C149  4.7uF  [CAP0402_0-75]
C150  0.1uF  [CAP0402_0-75]
C170  0.1uF  [CAP0402_0-75]
C184  22uF  [CAP0805_1-5]
C421  0.1uF  [CAP0402_0-75]
C427  0.1uF  [CAP0402_0-75]
C428  1uF  [CAP0402_0-75]
C430  2.2uF  [CAP0402_0-75]
C437  0.1uF  [CAP0402_0-75]
C438  2.2uF  [CAP0402_0-75]
C443  0.1uF  [CAP0402_0-75]
C446  0.1uF  [CAP0402_0-75]
C451  2.2uF  [CAP0402_0-75]
FB9  120E  [IND0603_1]
J37  CON_SDCARD10_DM3BT-DSF-PEJS  [CON_SD10_DM3BT-DSF-PEJS_S_R_S_2-4]
R159  49.9K_1%  [RES0402_0-5]
R160  49.9K_1%  [RES0402_0-5]
R161  49.9K_1%  [RES0402_0-5]
R162  49.9K_1%  [RES0402_0-5]
R163  49.9K_1%  [RES0402_0-5]
R164  49.9K_1%  [RES0402_0-5]
R165  49.9K_1%  [RES0402_0-5]
R166  49.9K_1%  [RES0402_0-5]
R193  10K  [RES0402_0-5]
R196  10K  [RES0402_0-5]
R389  0E  [RES0402_0-5]
R404  0E  [RES0402_0-5]
R405  10K_1%  [RES0402_0-5]
R416  10K  [RES0402_0-5]
R426  10K  [RES0402_0-5]
R444  10K  [RES0402_0-5]
R446  0E  [RES0402_0-5]
R456  49.9K_1%  [RES0402_0-5]
R457  49.9K_1%  [RES0402_0-5]
R479  10K  [RES0402_0-5]
R480  10K  [RES0402_0-5]
R481  10K  [RES0402_0-5]
R483  10K  [RES0402_0-5]
R484  10K  [RES0402_0-5]
R485  10K  [RES0402_0-5]
R644  10K  [RES0402_0-5]
R645  10K  [RES0402_0-5]
R646  10K  [RES0402_0-5]
TP39  TP20_SMD  [TP20_SMD]
U39  TPS22918DBVR  [SOT23-6]
U44  MTFC16GAPALBH-IT  [VFBGA153_19-68_460X520_1-1]
U49  TPD6E001RSER  [UQFN10_19-68_80X60_0-6]
U54  SN74LVC1G08DBVRE4  [SOT23-5]
U86  SN74LVC1G11DCKR  [SC70-6]
sheet 25.USB2.0 INTERFACE
U23  AM6442BSFGHAALV  [FCBGA441_31-49_680X680_2-6]  (sections A,B,C,D,E,F,G,H,I,J,K,L,M,N,O,P)
sheet 26.FT4232 UART TO USB BRIDGE
C152  10uF  [CAP0402_0-75]
C154  0.1uF  [CAP0402_0-75]
C158  2.2uF  [CAP0402_0-75]
C159  0.01uF  [CAP0402_0-75]
C160  1000pF  [CAP1206_1-75]
C407  0.1uF  [CAP0402_0-75]
C408  0.1uF  [CAP0402_0-75]
C409  0.1uF  [CAP0402_0-75]
C412  0.1uF  [CAP0402_0-75]
C413  0.1uF  [CAP0402_0-75]
C414  0.1uF  [CAP0402_0-75]
C416  0.1uF  [CAP0402_0-75]
C419  0.1uF  [CAP0402_0-75]
C420  0.1uF  [CAP0402_0-75]
C422  0.1uF  [CAP0402_0-75]
C423  0.1uF  [CAP0402_0-75]
C424  0.1uF  [CAP0402_0-75]
C425  0.1uF  [CAP0402_0-75]
C429  0.1uF  [CAP0402_0-75]
C433  18pF  [CAP0402_0-75]
C439  18pF  [CAP0402_0-75]
C440  0.1uF  [CAP0402_0-75]
C441  3.3uF  [CAP0603_1]
C442  0.1uF  [CAP0402_0-75]
C445  0.1uF  [CAP0402_0-75]
D6  TPD1E10B06DPYR  [DIO_DFN0402_0-5]
FB23  220E  [IND0402_0-6]
FB24  220E  [IND0402_0-6]
J26  CON_MUSB-B_5_F  [CON_MUSBB5_1051640001_S_R_S_2-5]
LD21  150080VS75000  [LED_150080VS75000_80X50_SMD_0-8]
R175  12K_1%  [RES0402_0-5]
R182  0E  [RES1206_0-75]
R186  10K  [RES0402_0-5]
R191  10K  [RES0402_0-5]
R192  2.2K  [RES0402_0-5]
R397  10K  [RES0402_0-5]
R400  10K  [RES0402_0-5]
R403  10K  [RES0402_0-5]
R406  10K  [RES0402_0-5]
R417  10K_1%  [RES0402_0-5]
R438  10K  [RES0402_0-5]
R445  10K  [RES0402_0-5]
R463  10K  [RES0402_0-5]
R464  220E  [RES0402_0-5]
R608  4.7K  [RES0402_0-5]
R609  4.7K  [RES0402_0-5]
R610  4.7K  [RES0402_0-5]
R611  4.7K  [RES0402_0-5]
U42  TPD4E004DRYR  [SON6_19-68_40X60_PB_0-6]
U43  TPS73533DRVR  [SON6_25-59_85X85]
U82  SN74AVC4T245RSVR  [UQFN16_TMUX1574_70X100_0-6]
U84  SN74AVC4T245RSVR  [UQFN16_TMUX1574_70X100_0-6]
U87  FT4232HL  [LQFP64_19-68_390X390_1-6]
U89  SN74AVC4T245RSVR  [UQFN16_TMUX1574_70X100_0-6]
U92  93LC46B  [MSOP8_25-59_125X125_1-1]
Y3  12.000MHz  [XTAL_ABM3_205X130_SMD_1-4]

## Library data of the parts
C148 C428 = CAP: CAP CERAMIC 1uF 10V 20% X5R 0402; Chkd/date: MANIRAJA/210820; Crtd /date: ALVY/190820; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 732-7489-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: WURTH ELECTRONICS; Mfr_part_number: 885012105012; Mistral Part No: 120020080009-R; Package: 0402; Part_type: CAPACITORS\CERAMIC; Project: AM64x_EVM_BRD; RoHS: RoHS; Temperature: -55°C+85°C; Tolerance: 20%; Voltage: 10V; Wattage: NA; Weight: 0.65mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\885012105012.PDF
C149 = CAP: CAP CERAMIC 4.7uF 10V 20% X5R 0402; Chkd/date: MANIRAJA/110718; Crtd /date: ALVY/110718; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 490-14306-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.65MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRM155R61A475MEAAD; Mistral Part No: 120012060002-R; Package: 0402; Part_type: CAPACITORS\CERAMIC; Project: TI_J7SVB_PCIE_ADD-ON-CARD; RoHS: RoHS; Temperature: -55°C+85°C; Tolerance: 20%; Voltage: 10V; Wattage: NA; Weight: 14mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRM155R61A475MEAAD.PDF
C150 C154 C170 C407-C409 C412-C414 C416 C419-C425 C427 C429 C437 C440 C442 C443 C445 C446 = CAP: CAP CERAMIC 0.1uF 25V 20% X5R 0402; Alt_Mfr_name: YAGEO AMERICA; Alt_Mfr_part_number: CC0402KRX5R8BB104; Chkd/date: MANIRAJA/170820; Crtd /date: ALVY/170820; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 732-7495-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: WURTH ELECTRONICS; Mfr_part_number: 885012105018; Mistral Part No: 120020080003-R; Package: 0402; Part_type: CAPACITORS\CERAMIC; Project: AM64x_EVM_BRD; RoHS: RoHS; Temperature: -55°C+85°C; Tolerance: 20%; Voltage: 25V; Wattage: NA; Weight: 0.65mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\885012105018.PDF
C184 = CAP: CAP CERAMIC 22uF 10V 20% X5R 0805; Chkd/date: MANIRAJA/210820; Crtd /date: ALVY/190820; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 732-7621-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 1.45MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: WURTH ELECTRONICS; Mfr_part_number: 885012107011; Mistral Part No: 120020080010-R; Package: 0805; Part_type: CAPACITORS\CERAMIC; Project: AM64x_EVM_BRD; RoHS: RoHS; Temperature: -55°C+85°C; Tolerance: 20%; Voltage: 10V; Wattage: NA; Weight: 5.5mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\885012107011.PDF
C158 C430 C438 C451 = CAP: CAP CERAMIC 2.2uF 10V 20% X5R 0402; Chkd/date: MANIRAJA/170820; Crtd /date: ALVY/170820; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 732-7490-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: WURTH ELECTRONICS; Mfr_part_number: 885012105013; Mistral Part No: 120019040036-R; Package: 0402; Part_type: CAPACITORS\CERAMIC; Project: AM64x_EVM_BRD; RoHS: RoHS; Temperature: -55°C+85°C; Tolerance: 20%; Voltage: 10V; Wattage: NA; Weight: 0.65mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\885012105013.PDF
FB9 = INDUCTOR_FERRITE: IND FERRITE BEAD CHIP 120E 2A 0603; Chkd/date: MANIRAJA/180820; Crtd /date: ALVY/180820; Custom_Duty: 24%; Customs_HS_Code: 85437099; Distributor_name: DIGIKEY; Distributor_part_number: 732-782631141CT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 1.00MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_FILTER_Library.schlib; Mfr_name: WURTH ELECTRONICS; Mfr_part_number: 782631141; Mistral Part No: 130020080015-R; Package: 0603; Part_type: INDUCTOR; Project: AM64x_EVM_BRD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 25%; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\DISCRETES\INDUCTORS\782631141.PDF
J37 = CON_SDCARD_10_DM3BT-DSF-PEJS: CON MICROSD CARD PUSH-PUSH 10POS FEMALE RM RA SMD; Chkd/date: MANIRAJA/080218; Crtd /date: BAVISH/190111; Custom_Duty: 24%; Customs_HS_Code: 85369090; Distributor_name: DIGIKEY; Distributor_part_number: HR1942CT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 2.38MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_CONNECTOR_Library.schlib; Mfr_name: HIROSE ELECTRIC; Mfr_part_number: DM3BT-DSF-PEJS; Mistral Part No: 150011010020-R; Package: SMD; Part_type: CONNECTOR\MEMORY CARD; Project: EBOOK; RoHS: RoHS; Temperature: -25°C+85°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 1.315g; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CONNECTORS\DM3-SERIES.PDF
R159-R166 R456 R457 = RESISTOR: RES 49.9K 1/16W 1% 0402; Chkd/date: MAZHAR/220709; Crtd /date: GEETHA/090606; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-49.9KLRCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0402FR-0749K9L; Mistral Part No: 110009030902-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: PNAV; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 1%; Voltage: NA; Wattage: 1/16W; Weight: 0.65mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R186 R191 R193 R196 R397 R400 R403 R406 R416 R426 R438 R444 R445 R463 R479-R481 R483-R485 R644-R646 = RESISTOR: RES 10K 1/16W 5% 0402; Chkd/date: VASANTHA/061216; Crtd /date: MAZHAR/230805; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-10KJRCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0402JR-0710KL; Mistral Part No: 110011060021-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: HSE; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 5%; Voltage: NA; Wattage: 1/16W; Weight: 0.65mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R389 R446 = RESISTOR: RES 0E 1/16W JUMPER 0402; Chkd/date: VASANTHA/201216; Crtd /date: MUDDU/190810; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 541-0.0JCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: VISHAY; Mfr_part_number: CRCW04020000Z0ED; Mistral Part No: 110010080019-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: PB_BUGBASE; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: NA; Voltage: NA; Wattage: 1/16W; Weight: 0.65mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\CRCW0603.PDF
R404 = RESISTOR: RES 0E 1/16W JUMPER 0402; Chkd/date: VASANTHA/201216; Crtd /date: MUDDU/190810; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 541-0.0JCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: VISHAY; Mfr_part_number: CRCW04020000Z0ED; Mistral Part No: 110010080019-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: PB_BUGBASE; RoHS: RoHS; SIGNAL_MODEL: RESISTOR_RES0402_22E_22E; Temperature: -55°C+155°C; Tolerance: NA; Voltage: NA; Wattage: 1/16W; Weight: 0.65mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\CRCW0603.PDF
R405 R417 = RESISTOR: RES 10K 1/16W 1% 0402; Chkd/date: VASANTHA/201216; Crtd /date: GEETHA/290506; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-10.0KLRTR-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0402FR-0710KL; Mistral Part No: 110015090015-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: VOCERA; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 1%; Voltage: NA; Wattage: 1/16W; Weight: 0.65mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
TP39 = TESTPOINT: TESTPOINT CIR 20 SMD; Chkd/date: SHREESHAIL/171006; Crtd /date: MAZHAR/171006; Custom_Duty: NA; Customs_HS_Code: NA; Distributor_name: NA; Distributor_part_number: NA; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: NA; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; MECHANICAL 3D STEP FILE: NA; Mfr_name: LOCAL; Mistral Part No: NA; Package: SMD; Project: BT MODULE_CSRBC04; RoHS: NA; Temperature: NA; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: NA
U39 = TPS22918DBVR_SOT23-6: IC ON RESISTANCE LOAD SWITCH SOT23-6; Automotive Alternate_mfr_name: TEXAS INSTRUMENTS; Automotive Alternate_mfr_part_number: TPS22918TDBVRQ1; Chkd/date: VASANTHA/130516; Crtd /date: VASANTHA/130516; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: TPS22918DBVR-ND; Height: 1.45MM; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 142016050007-R; Part_type: ICS\POWER; Project: TMDXCSK8127; RoHS: RoHS; Temperature: -40°C to 105°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\POWER\TPS22918DBV.PDF
U44 = MTFC16GAPALBH_TFBGA153: IC 16GB e-MMC MEMORY TFBGA153; Chkd/date: MANIRAJA/070220; Crtd /date: ALVY/070220; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: MTFC16GAPALBH-IT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 1.10MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_MISCMEMORY_Library.schlib; Mfr_name: MICRON; Mistral Part No: 141120020001-R; Package: TFBGA153; Part_type: ICS\DIGITAL\MEMORY; Project: TI_MAXIE_CPB; RoHS: RoHS; Temperature: -40°C+85°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\MEMORY\MTFCXX-IT.PDF
U49 = TPD6E001RSE_UQFN10: IC 6CH ESD-PROTECTION ARRAY UQFN10; Chkd/date: USMAN/070612; Crtd /date: BAVISH/160811; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: 296-21888-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.60MM; IBISSP_MODLES: Y:\MIS_DATABASE\IBIS\ICs\INTERFACE\TPD6E001RSE.IBS; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_MISCINTERFACE_Library.schlib; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 141011080020-R; Package: UQFN10; Part_type: ICS\INTERFACE; Project: DM385EVM_BASE-BOARD; RoHS: RoHS; Temperature: -40°C+85°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 7mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\INTERFACE\TPD6E001.PDF
U54 = SN74LVC1G08DBVRE4_SOT23-5: IC SINGLE 2-INPUT POSITIVE AND GATE SOT23-5; Chkd/date: SUHAS/221010; Crtd /date: USMAN/151008; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: SN74LVC1G08DBVRE4-ND; Height: 1.45MM; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 141009060026-R; Part_type: ICS\DIGITAL\GATES; Project: KHAN_MAIN; RoHS: Sb/ Br FREE; Temperature: -40°C+85°C; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\DIGITAL\GATES\SN74LVC1G08.PDF
U86 = SN74LVC1G11DCKR_SC70-6: IC SINGLE 3-INPUT POSITIVE-AND GATE SC70-6; Chkd/date: SHREESHAIL/220506; Crtd /date: MAZHAR/150506; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: 296-18066-1-ND; Height: 1.10MM; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 141009030230-R; Part_type: ICS\DIGITAL\GATES; Project: VOCERA; RoHS: Sb/ Br FREE; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\DIGITAL\GATES\SN74LVC1G.PDF
U23 = XAM6442BSFGGAALV_BGA441: IC AM64x SoC MICROPROCESSOR BGA441; Chkd/date: ALVY/300322; Crtd /date: ALVY/300322; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: NA; Distributor_part_number: NA; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 2.57MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_MICROPROCESSOR_Library.schlib; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 141220080002; Package: BGA441; Part_type: ICS\DIGITAL\MICROPROCESSOR; Project: AM64x-GP_EVM BRD; RoHS: NA; Temperature: NA; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\DIGITAL\MICROCONTROLLER\AM64-SoC_SVB.PDF
C152 = CAP: CAP CERAMIC 10uF 10V 20% X5R 0402; Chkd/date: MANIRAJA/300520; Crtd /date: ALVY/260520; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 490-GRM155R61A106ME11DTR-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRM155R61A106ME11D; Mistral Part No: 120013110019-R; Package: 0402; Part_type: CAPACITORS\CERAMIC; Project: QCS610_NANOSOM; RoHS: RoHS; Temperature: -55°C+85°C; Tolerance: 20%; Voltage: 10V; Wattage: NA; Weight: 3.1mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\MURATA-GXX-SER_NOV17.PDF
C159 = CAP: CAP CERAMIC 0.01uF 25V 10% X7R 0402; Chkd/date: MANIRAJA/170820; Crtd /date: ALVY/170820; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 732-7545-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: WURTH ELECTRONICS; Mfr_part_number: 885012205050; Mistral Part No: 120011090040-R; Package: 0402; Part_type: CAPACITORS\CERAMIC; Project: AM64x_EVM_BRD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 10%; Voltage: 25V; Wattage: NA; Weight: 0.65mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\885012205050.PDF
C160 = CAP: CAP CERAMIC 1000pF 2KV 10% X7R 1206; Chkd/date: SHREESHAIL/291106; Crtd /date: MAZHAR/281106; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 478-2956-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 1.52MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: AVX CORPORATION; Mfr_part_number: 1206GC102KAT1A; Mistral Part No: 120015080006-R; Package: 1206; Part_type: CAPACITORS\CERAMIC; Project: ADR1B; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 10%; Voltage: 2KV; Wattage: NA; Weight: 16.2mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\AVX_HV-MLC.PDF
C433 C439 = CAP: CAP CERAMIC 18pF 50V 5% C0G(NP0) 0402; Chkd/date: MANIRAJA/070220; Crtd /date: ALVY/070220; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 399-8952-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: KEMET; Mfr_part_number: C0402C180J5GAC7867; Mistral Part No: 120011090034-R; Package: 0402; Part_type: CAPACITORS\CERAMIC; Project: TI_MAXIE_CPB; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: 50V; Wattage: NA; Weight: 0.65mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\KEMET-C0G_SERIES.PDF
C441 = CAP: CAP CERAMIC 3.3uF 6.3V 20% X5R AUTO 0603; Chkd/date: ALVY/110221; Crtd /date: MANIRAJA/110221; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 445-12524-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.90MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: TDK; Mfr_part_number: CGA3E3X5R0J335M080AB; Mistral Part No: 120021020026-R; Package: 0603; Part_type: CAPACITORS\CERAMIC; Project: TI_AM243x LP EVM; RoHS: RoHS; Temperature: -55°C+85°C; Tolerance: 20%; Voltage: 6.3V; Wattage: NA; Weight: 6.3mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\CGA3E3X5R0J335M080AB.PDF
D6 = DIODE_SOD323: DIODE 1CH ESD PROTECTION X1SON2; Chkd/date: MANIRAJA/040420; Crtd /date: VASANTHA/181114; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: 296-30406-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.45MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 130014110022-R; Package: X1SON2; Part_type: DIODE; Project: GALILEO_EVM; RoHS: RoHS; Temperature: -40°C+125°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 1mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\INTERFACE\TPD1E10B06-SER.PDF
FB23 FB24 = INDUCTOR_FERRITE: IND FERRITE BEAD CHIP 220E 300mA 0402; Chkd/date: MANIRAJA/180820; Crtd /date: ALVY/180820; Custom_Duty: 24%; Customs_HS_Code: 85437099; Distributor_name: DIGIKEY; Distributor_part_number: 732-1569-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_FILTER_Library.schlib; Mfr_name: WURTH ELECTRONICS; Mfr_part_number: 742792780; Mistral Part No: 130020080018-R; Package: 0402; Part_type: INDUCTOR; Project: AM64x_EVM_BRD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 25%; Voltage: NA; Wattage: NA; Weight: 0.65mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\DISCRETES\INDUCTORS\742792780.PDF
J26 = CON_MUSB-B_5_1051640001: CON MICRO USB-B TYPE 5POS FEMALE RT SMD; Chkd/date: MANIRAJA/230817; Crtd /date: MANIRAJA/230817; Custom_Duty: 24%; Customs_HS_Code: 85369090; Distributor_name: DIGIKEY; Distributor_part_number: WM11263CT-ND; Height: 2.45MM; Mfr_name: MOLEX; Mfr_part_number: 1051640001; Mistral Part No: 150017080018-R; Package: SMD; Part_type: CONNECTOR\USB; Project: TI_MAXIE_CPB; RoHS: RoHS; Temperature: -35°C+85°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 234mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CONNECTORS\1051640001.PDF
LD21 = DIODE_LED: DIODE LED BRIGHT GREEN SMD; Chkd/date: MANIRAJA/180820; Crtd /date: ALVY/180820; Custom_Duty: 24%; Customs_HS_Code: 85439000; Distributor_name: DIGIKEY; Distributor_part_number: 732-4986-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.80MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_OPTO_Library.schlib; Mfr_name: WURTH ELECTRONICS; Mistral Part No: 130020080012-R; Package: SMD; Part_type: OPTO\LED; Project: AM64x_EVM_BRD; RoHS: RoHS; Temperature: -40°C+85°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 10mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\DISCRETES\LEDS\150080VS75000.PDF
R175 = RESISTOR: RES 12K 1/10W 1% 0402; Chkd/date: VASANTHA/041215; Crtd /date: VASANTHA/041215; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: P12.0KLCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: PANASONIC-ECG; Mfr_part_number: ERJ-2RKF1202X; Mistral Part No: 110019040053-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: TI_C5545; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 1%; Voltage: NA; Wattage: 1/10W; Weight: 0.8mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\PAN-ERJSER_NOV17.PDF
R182 = RESISTOR: RES 0E 1/4W JUMPER 1206; Chkd/date: MANIRAJA/150519; Crtd /date: ALVY/150519; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: RMCF1206ZT0R00CT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.70MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: STACKPOLE ELECTRONICS; Mfr_part_number: RMCF1206ZT0R00; Mistral Part No: 110010030045-R; Package: 1206; Part_type: RESISTORS\FIXED; Project: QCH HSAD_BRD; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: NA; Voltage: NA; Wattage: 1/4W; Weight: 8.86mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RMCF-SER_JUL18.PDF
R192 = RESISTOR: RES 2.2K 1/16W 5% 0402; Chkd/date: VASANTHA/061216; Crtd /date: BAVISH/021210; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-2.2KJRCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0402JR-072K2L; Mistral Part No: 110010120018-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: TE4; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 5%; Voltage: NA; Wattage: 1/16W; Weight: 0.65mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R464 = RESISTOR: RES 220E 1/10W 5% 0402; Chkd/date: VASANTHA/291216; Crtd /date: GEETHA/260406; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: P220JCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: PANASONIC-ECG; Mfr_part_number: ERJ-2GEJ221X; Mistral Part No: 110009030506-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: RED EYE; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 5%; Voltage: NA; Wattage: 1/10W; Weight: 0.8mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\PAN-ERJSER_NOV17.PDF
R608-R611 = RESISTOR: RES 4.7K 1/16W 5% 0402; Chkd/date: VASANTHA/130516; Crtd /date: VASANTHA/130516; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-4.7KJRCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0402JR-074K7L; Mistral Part No: 110011060001-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: TMDXCSK368; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 5%; Voltage: NA; Wattage: 1/16W; Weight: 0.65mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
U42 = TPD4E004_SON6: IC 4-CH ESD PROTECTION ARRAY FOR HIGH SPEED DATA INTERFACE SON6; Chkd/date: MANIRAJA/100320; Crtd /date: MUDDU/010310; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: 296-23618-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.60MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_MISCINTERFACE_Library.schlib; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 141010020012-R; Package: SON6; Part_type: ICS\INTERFACE; Project: BUG_BASE-II; RoHS: RoHS; Temperature: -40°C+85°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 3.2mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\INTERFACE\TPD4E004-SER.PDF
U43 = TPS73501DRVR_SON6: IC 500mA LOW DROPOUT REGULATOR SON6; Chkd/date: VASANTHA/280915; Crtd /date: NAVEED/011014; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: TPS73533DRVR-ND; Height: 0.80MM; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 142014100001-R; Package: SON6; Part_type: ICS\POWER\VOLTAGE REGULATOR; Project: BLUETOOTH_WATCH; RoHS: RoHS; Temperature: -40°C+125°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\POWER\TPS735.PDF
U82 U84 U89 = SN74AVC4T245RSV_UQFN16: IC 2-BIT BUS TRANSCEIVER WITH CONFIGURABLE VOLTAGE TRANSLATION AND 3 STATE O/P UQFN16; Chkd/date: MANIRAJA/040520; Crtd /date: BAVISH/190411; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: 296-24366-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_BUSDRIVERTRANSCEIVER_Library.schlib; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 141011040011-R; Package: UQFN16; Part_type: ICS\DIGITAL\BUSTRANSCEIVER; Project: HMC; RoHS: RoHS; Temperature: -40°C+85°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 41mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\DIGITAL\BUSTRANSCEIVER\SN74AVC4T245-SER.PDF
U87 = FT4232H__LQFP64: IC HIGH SPEED QUAD USB UART LQFP64; Chkd/date: MANIRAJA/110917; Crtd /date: VIJAYALAKSHMI/120813; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: 768-1026-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 1.60MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_COMBINATIONAL_Library.schlib; Library Ref: FT4232H_LQFP64; Mfr_name: FTDI; Mfr_part_number: FT4232HL-REEL; Mistral Part No: 141013080006-R; Package: LQFP64; Part_type: ICS\DIGITAL\PERIPHERAL; Project: DM37XX; RoHS: RoHS; Temperature: -40°C+85°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 342.7mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\DIGITAL\PERIPHERAL\FT4232HX.PDF
U92 = 93LC46B_MSOP8: IC 1K MICROWIRE COMPATIBLE SERIAL EEPROM MSOP8; Chkd/date: MANIRAJA/150218; Crtd /date: ALVY/150218; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: 93LC46B-I/MS-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 1.10MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_MISCMEMORY_Library.schlib; Mfr_name: MICROCHIP; Mfr_part_number: 93LC46B-I/MS; Mistral Part No: 141118020002-R; Package: MSOP8; Part_type: ICS\DIGITAL\MEMORY; Project: TI_MAXIE_CPB; RoHS: RoHS; Temperature: -40°C+85°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 140mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\MEMORY\93LC46B.PDF
Y3 = CRY: CRY 12.000MHz 18pF SMD; Chkd/date: MANIRAJA/310818; Crtd /date: MANIRAJA/310818; Custom_Duty: 24%; Customs_HS_Code: 85439000; Distributor_name: DIGIKEY; Distributor_part_number: CTX1170CT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 1.35MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: CTS; Mfr_part_number: 445I23D12M00000; Mistral Part No: 130018080040-R; Package: SMD; Part_type: CRYSTAL; Project: TI_MAXIE_CPB; RoHS: RoHS; Temperature: -40°C+85°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 50mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\MISC\CRY_OSC\445.PDF

## Nets
DGND: C148.2 C149.2 C150.2 C152.1 C154.1 C158.2 C159.1 C160.1 C170.2 C184.2 C407.1 C408.1 C409.1 C412.1 C413.1 C414.1 C416.1 C419.1 C420.1 C421.2 C422.1 C423.1 C424.1 C425.1 C427.2 C428.2 C429.1 C430.2 C433.2 C437.2 C438.2 C439.2 C440.1 C441.2 C442.1 C443.2 C445.1 C446.2 C451.2 D6.1 J26.5(GND) J37.6(VSS) J37.10 J37.11 J37.12(CD2) J37.13 J37.14 R175.1 R182.1 R397.1 R400.1 R405.2 R444.1 R445.1 R644.2 R645.2 U39.2(GND) U42.3(GND) U43.3(GND) U43.7(EP) U44.A6(VSS) U44.C4(VSSQ) U44.E7(VSS) U44.G5(VSS) U44.H10(VSS) U44.J5(VSS) U44.K8(VSS) U44.N2(VSSQ) U44.N5(VSSQ) U44.P4(VSSQ) U44.P6(VSSQ) U49.5(GND) U54.3(GND) U82.1(~{1OE}) U82.10(GND1) U82.11(GND2) U82.16(~{2OE}) U84.1(~{1OE}) U84.10(GND1) U84.11(GND2) U84.16(~{2OE}) U86.2(GND) U87.1(GND1) U87.5(GND2) U87.10(AGND) U87.11(GND3) U87.13(TEST) U87.15(GND4) U87.25(GND5) U87.35(GND6) U87.47(GND7) U87.51(GND8) U89.1(~{1OE}) U89.10(GND1) U89.11(GND2) U89.16(~{2OE}) U92.5(VSS) ; also on sheet 2 3 4 5 6 7 8 9 10 11 12 13 14 15 16 17 18 19 20 21 22 25 26 27 28 29 30 39 40
GNDUSB: C160.2 J26.SH1 J26.SH2 J26.SH3 J26.SH4 J26.SH5 J26.SH6 R182.2
VCC1V8: C170.1 C430.1 C443.1 R159.1 R160.1 R161.1 R162.1 R163.1 R164.1 R165.1 R166.1 R193.1 R456.1 R457.1 U44.C6(VCCQ) U44.M4(VCCQ) U44.N4(VCCQ) U44.P3(VCCQ) U44.P5(VCCQ) U54.5(VCC) ; also on sheet 11 12 13 14 15 18 21
VCC_1V8_FT4232: C419.2 C420.2 C440.2 C441.1 U87.12(VCORE) U87.37(VCORE) U87.49(VREGOUT) U87.64(VCORE)
VCC_3V3_FT4232: C158.1 C409.2 C412.2 C413.2 C414.2 C423.2 C424.2 C442.2 C445.2 FB23.2 FB24.2 LD21.2(ANODE) R186.2 R191.2 R463.2 U43.1(OUT) U82.2(VCCB) U84.2(VCCB) U87.20(VCCIO) U87.31(VCCIO) U87.42(VCCIO) U87.50(VREGIN) U87.56(VCCIO) U89.2(VCCB) U92.8(VCC)
VCC_3V3_SYS: C149.1 C150.1 C407.2 C408.2 C421.1 C429.2 C437.1 C438.1 R196.2 R403.2 R406.2 R416.2 R426.1 R438.2 R481.1 R608.1 R609.1 R610.1 R611.1 U39.1(VIN) U44.E6(VCC) U44.F5(VCC) U44.J10(VCC) U44.K9(VCC) U82.3(VCCA) U84.3(VCCA) U86.5(VCC) U89.3(VCCA) ; also on sheet 2 5 6 7 8 10 11 12 13 14 15 16 17 18 19 20 21 25 26 27 29 30 39 40
VDD_MMC1: C148.1 C184.1 FB9.1 U39.5(QOD) U39.6(VOUT) ; also on sheet 3 4
VDD_MMC1_SD: C451.1 FB9.2 J37.4(VDD)
VDDIM: C427.1 C428.1 U44.C2(VDDIM)
VDDSHV_SD_IO: C446.1 R479.1 R480.1 R483.1 R484.1 R485.1 R646.1 TP39.1(TP) U49.10(VCC) ; also on sheet 3 4
eMMC_RSTn: R193.2 U44.K5(RST_N) U54.4(Y)
FT4232_DO: R191.1 R192.2 U92.4(DO)
FT4232_EECLK: R186.1 U87.62(EECLK) U92.2(CLK)
FT4232_EECS: R463.1 U87.63(EECS) U92.1(CS)
FT4232_EEDATA: R192.1 U87.61(EEDATA) U92.3(DI)
FT4232_MCU_UART0_CTS_3V3: U82.12(2B2) U87.28(BDBUS2)
FT4232_MCU_UART0_RTS_3V3: U82.14(1B2) U87.29(BDBUS3)
FT4232_MCU_UART0_RX_3V3: U82.13(2B1) U87.26(BDBUS0)
FT4232_MCU_UART0_TX_3V3: U82.15(1B1) U87.27(BDBUS1)
FT4232_REF: R175.2 U87.6(REF)
FT4232_RESET: C416.2 R417.1 U87.14(~{RESET})
FT4232_UART0_CTS_3V3: U84.12(2B2) U87.18(ADBUS2)
FT4232_UART0_RTS_3V3: U84.14(1B2) U87.19(ADBUS3)
FT4232_UART0_RX_3V3: U84.13(2B1) U87.16(ADBUS0)
FT4232_UART0_TX_3V3: U84.15(1B1) U87.17(ADBUS1)
FT4232_UART1_RX_3V3: U87.38(CDBUS0) U89.13(2B1)
FT4232_UART1_TX_3V3: U87.39(CDBUS1) U89.15(1B1)
FT4232_UART3_RX_3V3: U87.48(DDBUS0) U89.12(2B2)
FT4232_UART3_TX_3V3: U87.52(DDBUS1) U89.14(1B2)
FT4232_USB_DM: J26.2(D-) U42.5(IO4) U87.7(DM)
FT4232_USB_DP: J26.3(D+) U42.4(IO3) U87.8(DP)
FT4232_USB_VBUS: C152.2 C154.2 D6.2 J26.1(VBUS) U42.6(VCC) U43.4(EN) U43.6(IN)
FT_PWREN#: R464.1 U87.60(~{PWREN})
GPIO_eMMC_RSTn: R196.1 U54.1(A) ; also on sheet 13
IO_EXP_INTn_SDIO: U23.C20(MMC1_SDWP) ; also on sheet 13
MCU_UART0_CTS_3V3: U82.9(2A2) ; also on sheet 12
MCU_UART0_RTS_3V3: U82.7(1A2) ; also on sheet 12
MCU_UART0_RX_3V3: U82.8(2A1) ; also on sheet 12
MCU_UART0_TX_3V3: R611.2 U82.6(1A1) ; also on sheet 12
MMC0_CALPAD: R405.1 U23.F18(MMC0_CALPAD)
MMC0_CLK: R404.1 R456.2 R644.1 U44.M6(CLK)
MMC0_DS: R444.2 R446.2 U44.H5(DS)
MMC1_CLK: J37.5(CLK) R389.1 R645.1 R646.2 U49.1(IO1)
MMC1_CLK_R: R389.2 U23.L20(MMC1_CLK)
MMC1_CMD: J37.3(CMD) R485.2 U23.J19(MMC1_CMD) U49.2(IO2)
MMC1_D0: J37.7(DAT0) R479.2 U23.K21(MMC1_DAT0) U49.8(IO6)
MMC1_D1: J37.8(DAT1) R480.2 U23.L21(MMC1_DAT1) U49.7(IO5)
MMC1_D2: J37.1(DAT2) R483.2 U23.K19(MMC1_DAT2) U49.6(IO4)
MMC1_D3: J37.2(CD/DAT3) R484.2 U23.K18(MMC1_DAT3) U49.3(IO3)
MMC1_SD_EN: R416.1 U86.1(A) ; also on sheet 13
MMC1_SD_LS_EN: R426.2 U39.3(ON) U86.4(Y)
MMC1_SDCD: J37.9(CD1) R481.2 U23.D19(MMC1_SDCD)
PORz_OUT: U86.6(C) ; also on sheet 2 12 29 39 40
RESETSTATz: U54.2(B) U86.3(B) ; also on sheet 5 11 12 13 21 29
SOC_MAIN_UART0_CTS_3V3: U84.9(2A2) ; also on sheet 6
SOC_MAIN_UART0_RTS_3V3: U84.7(1A2) ; also on sheet 6
SOC_MAIN_UART0_RX_3V3: U84.8(2A1) ; also on sheet 6
SOC_MAIN_UART0_TX_3V3: R608.2 U84.6(1A1) ; also on sheet 6
SOC_MAIN_UART1_RX_3V3: U89.8(2A1) ; also on sheet 6
SOC_MAIN_UART1_TX_3V3: R609.2 U89.6(1A1) ; also on sheet 6
SOC_MAIN_UART3_RX_3V3: U89.9(2A2) ; also on sheet 6
SOC_MAIN_UART3_TX_3V3: R610.2 U89.7(1A2) ; also on sheet 6
SoC_MMC0_CLK: R404.2 U23.G18(MMC0_CLK)
SoC_MMC0_CMD: R457.2 U23.J21(MMC0_CMD) U44.M5(CMD)
SoC_MMC0_DAT0: R161.2 U23.K20(MMC0_DAT0) U44.A3(DAT0)
SoC_MMC0_DAT1: R163.2 U23.J20(MMC0_DAT1) U44.A4(DAT1)
SoC_MMC0_DAT2: R165.2 U23.J18(MMC0_DAT2) U44.A5(DAT2)
SoC_MMC0_DAT3: R159.2 U23.J17(MMC0_DAT3) U44.B2(DAT3)
SoC_MMC0_DAT4: R160.2 U23.H17(MMC0_DAT4) U44.B3(DAT4)
SoC_MMC0_DAT5: R162.2 U23.H19(MMC0_DAT5) U44.B4(DAT5)
SoC_MMC0_DAT6: R164.2 U23.H18(MMC0_DAT6) U44.B5(DAT6)
SoC_MMC0_DAT7: R166.2 U23.G17(MMC0_DAT7) U44.B6(DAT7)
SoC_MMC0_DS: R446.1 U23.G19(MMC0_DS)
VPHY_3V3_FT4232: C425.2 FB24.1 U87.4(VPHY)
VPLL_3V3_FT4232: C422.2 FB23.1 R417.2 U87.9(VPLL)
N15507744: C159.2 U43.2(NR/FB)
N16814557: R445.2 U89.5(2DIR)
N16814563: R438.1 U89.4(1DIR)
N16814605: R400.2 U84.5(2DIR)
N16814611: R406.1 U84.4(1DIR)
N16814651: R397.2 U82.5(2DIR)
N16814659: R403.1 U82.4(1DIR)
N18977129: C433.1 U87.3(OSCO) Y3.2
N18977189: C439.1 U87.2(OSCI) Y3.1
N26881621: LD21.1(CATHODE) R464.2

Not connected (* = marked no-connect by the designer): J26 4(ID)*; U39 4(CT)*; U42 1(IO1)* 2(IO2)*; U43 5(NC)*; U44 A1(NC1)* A2(NC2)* A7(RFU1)* A8(NC3)* A9(NC4)* A10(NC5)* A11(NC6)* A12(NC7)* A13(NC8)* A14(NC9)* B1(NC10)* B7(NC11)* B8(NC12)* B9(NC13)* B10(NC14)* B11(NC15)* B12(NC16)* B13(NC17)* B14(NC18)* C1(NC19)* C3(NC20)* C5(NC21)* C7(NC22)* C8(NC23)* C9(NC24)* C10(NC25)* C11(NC26)* C12(NC27)* C13(NC28)* C14(NC29)* D1(NC30)* D2(NC31)* D3(NC32)* D4(NC33)* D12(NC34)* D13(NC35)* D14(NC36)* E1(NC37)* E2(NC38)* E3(NC39)* E5(RFU2)* E8(VSF1)* E9(VSF2)* E10(VSF3)* E12(NC40)* E13(NC41)* E14(NC42)* F1(NC43)* F2(NC44)* F3(NC45)* F10(VSF4)* F12(NC46)* F13(NC47)* F14(NC48)* G1(NC49)* G2(NC50)* G3(NC51)* G10(VSF5)* G12(NC52)* G13(NC53)* G14(NC54)* H1(NC55)* H2(NC56)* H3(NC57)* H12(NC58)* H13(NC59)* H14(NC60)* J1(NC61)* J2(NC62)* J3(NC63)* J12(NC64)* J13(NC65)* J14(NC66)* K1(NC67)* K2(NC68)* K3(NC69)* K6(RFU3)* K7(RFU4)* K10(VSF6)* K12(NC70)* K13(NC71)* K14(NC72)* L1(NC73)* L2(NC74)* L3(NC75)* L12(NC76)* L13(NC77)* L14(NC78)* M1(NC79)* M2(NC80)* M3(NC81)* M7(NC82)* M8(NC83)* M9(NC84)* M10(NC85)* M11(NC86)* M12(NC87)* M13(NC88)* M14(NC89)* N1(NC90)* N3(NC91)* N6(NC92)* N7(NC93)* N8(NC94)* N9(NC95)* N10(NC96)* N11(NC97)* N12(NC98)* N13(NC99)* N14(NC100)* P1(NC101)* P2(NC102)* P7(NC103)* P8(NC104)* P9(NC105)* P10(VSF7)* P11(NC106)* P12(NC107)* P13(NC108)* P14(NC109)*; U49 4(NC1)* 9(NC2)*; U87 21(ADBUS4)* 22(ADBUS5)* 23(ADBUS6)* 24(ADBUS7)* 30(BDBUS4)* 32(BDBUS5)* 33(BDBUS6)* 34(BDBUS7)* 36(~{SUSPEND}) 40(CDBUS2)* 41(CDBUS3)* 43(CDBUS4)* 44(CDBUS5)* 45(CDBUS6)* 46(CDBUS7)* 53(DDBUS2)* 54(DDBUS3)* 55(DDBUS4)* 57(DDBUS5)* 58(DDBUS6)* 59(DDBUS7)*; U92 6(NC1)* 7(NC2)*

## Notes on the sheets
sheet 23
- FT4232 UART
- D-Note :-
  Follow SK-AM62P-LP SK
  implementations for latest
  updates on  FT4232
- R-Note:-
  Verify the implementation with
  the device manufacturer
- USB Micro B
- D-Note :-
  Add a filter
  cap (0.1uF)
- FT4232: 5V to 3.3V@500mA LDO
- FT4232 LEVEL TRANSLATOR
- Off Page Connections
- EEPROM
sheet 24
- D-Note :-
  This family of processor implements a hard and dedicated
  PHY for eMMC interface.
  The pull required for D0..D7, Clock and other eMMC
  interface control signals are enabled internal to the
  SOC during reset
  Refer pin connectivity table for guidelines when eMMC is
  not used
- eMMC FLASH
- D-Note :-
  The pulls required for D0..D7,
  Clock and other eMMC interface
  control signals are enabled
  internal to the SOC during reset
  and are eMMC JEDEC standard
  compliant
  External pullup is optional and
  can be deleted on the custom board
  Refer pin connectivity table for
  guidelines when eMMC is not used
- D-Note :-
  0E provision on MMC0_CLK
  Helps improve signal integrity
- SOC - MMC INTERFACE
- D-Note :-
  Add additional
  decaps as required
  Refer SK-AM62P-LP
  schematics
- D-Note :-
  MMC0 interface is compliant
  with the JEDEC eMMC electrical
  standard v5.1 (JESD84-B51)
- R-Note :-
  What is the reason we
  selected pulldown
  instead of pullup for
  EMMC,  SD card or other
  peripherals?
  Because there are cases
  where the clock is
  stopped or paused in a
  low logic state and the
  pull-down option is
  consistent with this
  logic state.
- D-Note :-
  Ensure eMMC_RSTn Reset input is
  enabled in the eMMC device (eMMC
  non-volatile configuration space) for
  the reset logic to be functional
- CAD Note  :-
  Place SOC clock output pulldown
  resistor near to the clock input
  pin of the attached (memory) device
- eMMC FLASH RESET
- D-Note :-
  The GPIO reset option makes it possible for software to reset
  the attached device (eMMC or OSPI or SD card or OLDI0 or EPHY)
  without resetting the entire processor if there is a case
  where the peripheral becomes unresponsive.
- D-Note :-
  Add a series resistor to the
  GPIO input for isolation or
  testing
  Refer SK-AM62P-LP schematics
- D-Note :-
  You could eliminate the GPIO option and only use the reset
  output (Warm or Cold), where software forces a warm reset
  if the peripheral becomes unresponsive. However, this will
  reset the entire device rather than trying to recover the
  specific peripheral without resetting the entire device.
- D-Note :-
  In case ANDing logic is not used and the processor
  Main Domain warm reset status output (RESETSTATz)
  is used to reset the attached device, ensure the
  IO voltage level of the attached device matches
  the RESETSTATz IO voltage  level. A level
  translator is recommended to match the IO voltage
  level. A resistor divider could be used
  alternatively, provided optimum impedance value of
  the  resistor divider is selected. If too high the
  rise/fall  time of the eMMC reset input could be
  slow and introduce  too much delay. If too low it
  will cause the AM62x to source too much
  steady-state current during normal  operation.
- D-Note :-
  ANDing logic additionally
  performs level translation
  Verify the Reset IO level
  compatibility before
  optimizing the reset ANDing
  logic.
  IO level mismatch could
  cause supply leakage and
  affect SOC operation
- D-Note :-
  For UHS-I operation, the
  pullups are recommended to
  be connected to the
  3.3V/1.8V switched LDO
  output
- SD CARD INTERFACE
- D-Note :-
  Ensure internal pullups are not
  configured when 10K external
  pullups are used. As a good design
  practice, a 47K pullup is
  recommended to ensure the pullup
  value is within the SD card
  specification, when internal pulls
  are enabled unexpectedly. This way
  the resulting pull resistance will
  still be within the specified.
- D-Note :-
  Add a decap
- D-Note :-
  Add an external ESD
  protection for
  MMC1_SDCD
- D-Note :-
  CT - Add a 220 pF or
  higher cap for SD card
  supply slew rate
  control
- D-Note :-
  Add a series
  resistor to the GPIO
  input for isolation
  or testing
  Refer SK-AM62P-LP
  schematics
- D-Note :-
  Anding logic could be
  optimized to 2 input AND
  gate
  Use RESETSTATz and the
  SoC IO as inputs
- Off Page Connections
- From &
  To IO Expander
- D-Note :-
  This power switch, along with the reset logic, and the host IO power supply circuit is required to
  support UHS-I SD Cards which begins communications
   using 3.3V signal levels and later change to 1.8V signal levels when changing to one of the faster
  data transfer speeds.
  Cycling power to the SD Card is the only way to put it back into 3.3V mode since SD Cards do not
  have a reset pin.
  The host IO power supply must power off/on and change voltage at the same time as the SD Card.
  These circuits and the software driver operating
   the signals sourcing these circuits ensure both devices are off, or on and operating at the same
  IO voltage at the same time.
