# OrCAD Capture schematic PROC101D_SCH_With_Design_Updates..Notes_V1.0.DSN, sheets 4 to 5 of 40

## Sheets
4 09.SOC POWER: size C; title: SOC POWER
5 30.PCIe INTERFACE: size C; title: PCIe INTERFACE; note: PROC067

## Parts
sheet 09.SOC POWER
C74  4.7uF  [CAP0402_0-75]
C75  0.1uF  [CAP0201_0-5]
C88  4.7uF  [CAP0402_0-75]
C91  0.1uF  [CAP0201_0-5]
C92  0.1uF  [CAP0201_0-5]
C93  0.1uF  [CAP0201_0-5]
C103  4.7uF  [CAP0402_0-75]
C120  4.7uF  [CAP0402_0-75]
C121  0.1uF  [CAP0201_0-5]
C289  1uF  [CAP0201_0-5]
C298  1uF  [CAP0201_0-5]
C299  4.7uF  [CAP0402_0-75]
C300  0.1uF  [CAP0201_0-5]
C322  0.01uF  [CAP0201_0-5]
C327  4.7uF  [CAP0402_0-75]
C340  0.1uF  [CAP0201_0-5]
C341  4.7uF  [CAP0402_0-75]
C344  0.01uF  [CAP0201_0-5]
C347  0.01uF  [CAP0201_0-5]
C348  1uF  [CAP0201_0-5]
C350  0.01uF  [CAP0201_0-5]
C353  0.01uF  [CAP0201_0-5]
C355  0.01uF  [CAP0201_0-5]
C356  0.01uF  [CAP0201_0-5]
C357  1uF  [CAP0201_0-5]
C358  0.1uF  [CAP0201_0-5]
C362  0.01uF  [CAP0201_0-5]
C363  4.7uF  [CAP0402_0-75]
C365  0.1uF  [CAP0201_0-5]
C368  0.1uF  [CAP0201_0-5]
C373  0.01uF  [CAP0201_0-5]
C375  0.01uF  [CAP0201_0-5]
C377  4.7uF  [CAP0402_0-75]
C380  0.01uF  [CAP0201_0-5]
C387  0.1uF  [CAP0201_0-5]
C390  1uF  [CAP0201_0-5]
C391  1uF  [CAP0201_0-5]
C396  1uF  [CAP0201_0-5]
C398  4.7uF  [CAP0402_0-75]
C399  0.1uF  [CAP0201_0-5]
C400  3.3uF  [CAP0603_1]
FB3  120E  [IND0603_1]
FB4  26E  [IND0603_1]
FB5  120E  [IND0603_1]
FB6  120E  [IND0603_1]
FB13  120E  [IND0603_1]
FB15  120E  [IND0603_1]
FB16  26E  [IND0603_1]
FB17  26E  [IND0603_1]
FB18  120E  [IND0603_1]
FB20  120E  [IND0603_1]
R75  0E  [RES1210_0-75]
R78  0E  [RES1210_0-75]
R106  0E  [RES1210_0-75]
R297  0E  [RES1210_0-75]
R314  100K  [RES0402_0-5]
R315  11K_1%  [RES0402_0-5]
R604  255K_1%  [RES0402_0-5]
R698  0E  [RES0201_0-5]
R699  0E  [RES0201_0-5]
sheet 25.USB2.0 INTERFACE
U23  AM6442BSFGHAALV  [FCBGA441_31-49_680X680_2-6]  (sections A,B,C,D,E,F,G,H,I,J,K,L,M,N,O,P)
sheet 30.PCIe INTERFACE
C100  0.22uF  [CAP0201_0-5]
C102  0.22uF  [CAP0201_0-5]
C426  0.1uF  [CAP0402_0-75]
C431  0.1uF  [CAP0402_0-75]
C432  0.01uF  [CAP0402_0-75]
C435  0.1uF  [CAP0402_0-75]
C436  0.01uF  [CAP0402_0-75]
C448  47uF  [CAP1206_2]
C449  0.1uF  [CAP0402_0-75]
C450  0.01uF  [CAP0402_0-75]
J27  CON_MINIPCI_2X32  [CON_MINIPCI2X32_PCIE-064-02_S_S_T_11]
J34  HDR_1X3  [HDR_3X1_100_S_T]
J35  HDR_1X3  [HDR_3X1_100_S_T]
R333  49.9E_1%  [RES0402_0-5]
R338  3.01K_1%  [RES0402_0-5]
R346  49.9E_1%  [RES0402_0-5]
R424  10K  [RES0402_0-5]
R430  10K  [RES0402_0-5]
R431  10K  [RES0402_0-5]
R437  0E  [RES0402_0-5]
R482  10K  [RES0402_0-5]
R486  10K  [RES0402_0-5]
R493  0E  [RES0402_0-5]
R576  10K  [RES0402_0-5]
R622  1K_1%  [RES0402_0-5]
R623  1K_1%  [RES0402_0-5]
R624  1.5K  [RES0402_0-5]
R625  1.5K  [RES0402_0-5]
R632  0E  [RES0402_0-5]
R661  0E  [RES0402_0-5]
R662  0E  [RES0402_0-5]
R665  0E  [RES0402_0-5]
R666  0E  [RES0402_0-5]
R667  0E  [RES0402_0-5]
R668  0E  [RES0402_0-5]
R679  0E  [RES0402_0-5]
R680  0E  [RES0402_0-5]
TP83  TP20_SMD  [TP20_SMD]
TP84  TP20_SMD  [TP20_SMD]
TP85  TP20_SMD  [TP20_SMD]
TP94  TP20_SMD  [TP20_SMD]
TP95  TP20_SMD  [TP20_SMD]
U88  SN74LVC1G08DBVRE4  [SOT23-5]

## Library data of the parts
C74 C88 C103 C120 C299 C327 C341 C363 C377 C398 = CAP: CAP CERAMIC 4.7uF 10V 20% X5R 0402; Chkd/date: MANIRAJA/230118; Crtd /date: MANIRAJA/230118; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 478-10791-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.71MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: AVX CORPORATION; Mfr_part_number: 0402ZD475MAT2A; Mistral Part No: 120012060002-R; Package: 0402; Part_type: CAPACITORS\CERAMIC; Project: TI_MAXIE_CPB; RoHS: RoHS; Temperature: -55°C+85°C; Tolerance: 20%; Voltage: 10V; Wattage: NA; Weight: 0.65mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\AVX_MLC.PDF
C75 C91-C93 C121 C300 C340 C358 C365 C368 C387 C399 = CAP: CAP CERAMIC 0.1uF 16V 10% X5R 0201; Chkd/date: MANIRAJA/120218; Crtd /date: MANIRAJA/120218; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 490-16742-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.33MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRM033R61C104KE84J; Mistral Part No: 120009030072-R; Package: 0201; Part_type: CAPACITORS\CERAMIC; Project: TI_MAXIE_CPB; RoHS: RoHS; Temperature: -55°C+85°C; Tolerance: 10%; Voltage: 16V; Wattage: NA; Weight: 0.33mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRM033R61C104KE84.PDF
C289 C298 C348 C357 C390 C391 C396 = CAP: CAP CERAMIC 1uF 6.3V 20% X5R 0201; Chkd/date: MANIRAJA/091219; Crtd /date: ALVY/091219; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 490-7229-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.35MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRM033R60J105MEA2D; Mistral Part No: 120012060001-R; Package: 0201; Part_type: CAPACITORS\CERAMIC; Project: MYTHIC_X16_BRD; RoHS: RoHS; Temperature: -55°C+85°C; Tolerance: 20%; Voltage: 6.3V; Wattage: NA; Weight: 7mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRM033R60J105MEA2.PDF
C322 C344 C347 C350 C353 C355 C356 C362 C373 C375 C380 = CAP: CAP CERAMIC 0.01uF 25V 10% X5R 0201; Chkd/date: MANIRAJA/230118; Crtd /date: MANIRAJA/230118; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: GRM033R61E103KA12J-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.33MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRM033R61E103KA12J; Mistral Part No: 120018010007-R; Package: 0201; Part_type: CAPACITORS\CERAMIC; Project: TI_MAXIE_CPB; RoHS: RoHS; Temperature: -55°C+85°C; Tolerance: 10%; Voltage: 25V; Wattage: NA; Weight: 0.33mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRM033R61E103KA12.PDF
C400 = CAP: CAP CERAMIC 3.3uF 6.3V 20% X5R AUTO 0603; Chkd/date: ALVY/110221; Crtd /date: MANIRAJA/110221; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 445-12524-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.90MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: TDK; Mfr_part_number: CGA3E3X5R0J335M080AB; Mistral Part No: 120021020026-R; Package: 0603; Part_type: CAPACITORS\CERAMIC; Project: TI_AM243x LP EVM; RoHS: RoHS; Temperature: -55°C+85°C; Tolerance: 20%; Voltage: 6.3V; Wattage: NA; Weight: 6.3mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\CGA3E3X5R0J335M080AB.PDF
FB3 FB5 FB6 FB13 FB15 FB18 FB20 = INDUCTOR_FERRITE: IND FERRITE BEAD CHIP 120E 2A 0603; Chkd/date: MANIRAJA/180820; Crtd /date: ALVY/180820; Custom_Duty: 24%; Customs_HS_Code: 85437099; Distributor_name: DIGIKEY; Distributor_part_number: 732-782631141CT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 1.00MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_FILTER_Library.schlib; Mfr_name: WURTH ELECTRONICS; Mfr_part_number: 782631141; Mistral Part No: 130020080015-R; Package: 0603; Part_type: INDUCTOR; Project: AM64x_EVM_BRD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 25%; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\DISCRETES\INDUCTORS\782631141.PDF
FB4 FB16 FB17 = INDUCTOR_FERRITE: IND FERRITE BEAD CHIP 26E 6.5A 0603; Chkd/date: MANIRAJA/180820; Crtd /date: ALVY/180820; Custom_Duty: 24%; Customs_HS_Code: 85437099; Distributor_name: DIGIKEY; Distributor_part_number: 732-6117-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 1.00MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_FILTER_Library.schlib; Mfr_name: WURTH ELECTRONICS; Mfr_part_number: 74279228260; Mistral Part No: 130020080017-R; Package: 0603; Part_type: INDUCTOR; Project: AM64x_EVM_BRD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 25%; Voltage: NA; Wattage: NA; Weight: 2mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\DISCRETES\INDUCTORS\74279228260.PDF
R75 R78 R106 R297 = RESISTOR: RES 0E 1/2W 5% 1210; Chkd/date: VASANTHA/281216; Crtd /date: USMAN/080109; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: MOUSER; Distributor_part_number: 603-RC1210JR-070RL; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.65MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC1210JR-070RL; Mistral Part No: 110009030080-R; Package: 1210; Part_type: RESISTORS\FIXED; Project: OMAP_EVM; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 5%; Voltage: NA; Wattage: 1/2W; Weight: 10mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R314 = RESISTOR: RES 100K 1/16W 5% 0402; Chkd/date: VASANTHA/061216; Crtd /date: BAVISH/010611; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 541-100KJCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: VISHAY; Mfr_part_number: CRCW0402100KJNED; Mistral Part No: 110011060002-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: AM4515_EVM_LCD; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 5%; Voltage: NA; Wattage: 1/16W; Weight: 0.65mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\CRCW0603.PDF
R315 = RESISTOR: RES 11K 1/16W 1% 0402; Chkd/date: VASANTHA/251115; Crtd /date: VASANTHA/251115; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-11.0KLRCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0402FR-0711KL; Mistral Part No: 110015110012-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: TI_VLAN_SWITCH; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 1%; Voltage: NA; Wattage: 1/16W; Weight: 0.65mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R604 = RESISTOR: RES 255K 1/10W 1% 0402; Chkd/date: MANIRAJA/160218; Crtd /date: MANIRAJA/160218; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: P255KLCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: PANASONIC-ECG; Mfr_part_number: ERJ-2RKF2553X; Mistral Part No: 110018020016-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: NPOL_SAR_ADC; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 1%; Voltage: NA; Wattage: 1/10W; Weight: 0.8mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\PAN-ERJSER_NOV17.PDF
R698 R699 = RESISTOR: RES 0E 1/20W 5% 0201; Chkd/date: NAVEED/301214; Crtd /date: MUDDU/120710; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-0.0NCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.26MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0201JR-070RL; Mistral Part No: 110010070067-R; Package: 0201; Part_type: RESISTORS\FIXED; Project: PB_BUGBASE; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: NA; Wattage: 1/20W; Weight: 0.17mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
U23 = XAM6442BSFGGAALV_BGA441: IC AM64x SoC MICROPROCESSOR BGA441; Chkd/date: ALVY/300322; Crtd /date: ALVY/300322; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: NA; Distributor_part_number: NA; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 2.57MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_MICROPROCESSOR_Library.schlib; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 141220080002; Package: BGA441; Part_type: ICS\DIGITAL\MICROPROCESSOR; Project: AM64x-GP_EVM BRD; RoHS: NA; Temperature: NA; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\DIGITAL\MICROCONTROLLER\AM64-SoC_SVB.PDF
C100 C102 = CAP: CAP CERAMIC 0.22uF 6.3V 10% X6S 0201; Chkd/date: ALVY/290621; Crtd /date: MANIRAJA/290621; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 490-10392-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.33MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRM033C80J224KE90D; Mistral Part No: 120021060017-R; Package: 0201; Part_type: CAPACITORS\CERAMIC; Project: TI_J7AEP_EVM; RoHS: RoHS; Temperature: -55°C+105°C; Tolerance: 10%; Voltage: 6.3V; Wattage: NA; Weight: 0.33mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRM033C80J224KE90.PDF
C426 C431 C435 C449 = CAP: CAP CERAMIC 0.1uF 25V 20% X5R 0402; Alt_Mfr_name: YAGEO AMERICA; Alt_Mfr_part_number: CC0402KRX5R8BB104; Chkd/date: MANIRAJA/170820; Crtd /date: ALVY/170820; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 732-7495-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: WURTH ELECTRONICS; Mfr_part_number: 885012105018; Mistral Part No: 120020080003-R; Package: 0402; Part_type: CAPACITORS\CERAMIC; Project: AM64x_EVM_BRD; RoHS: RoHS; Temperature: -55°C+85°C; Tolerance: 20%; Voltage: 25V; Wattage: NA; Weight: 0.65mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\885012105018.PDF
C432 C436 C450 = CAP: CAP CERAMIC 0.01uF 25V 10% X7R 0402; Chkd/date: MANIRAJA/170820; Crtd /date: ALVY/170820; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 732-7545-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: WURTH ELECTRONICS; Mfr_part_number: 885012205050; Mistral Part No: 120011090040-R; Package: 0402; Part_type: CAPACITORS\CERAMIC; Project: AM64x_EVM_BRD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 10%; Voltage: 25V; Wattage: NA; Weight: 0.65mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\885012205050.PDF
C448 = CAP: CAP CERAMIC 47uF 25V 20% X5R 1206; Chkd/date: MANIRAJA/230118; Crtd /date: MANIRAJA/230118; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 490-16268-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 1.80MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRM31CR61E476ME44L; Mistral Part No: 120013050002-R; Package: 1206; Part_type: CAPACITORS\CERAMIC; Project: TI_MAXIE_CPB; RoHS: RoHS; Temperature: -55°C+85°C; Tolerance: 20%; Voltage: 25V; Wattage: NA; Weight: 40mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\MURATA-GXX-SER_NOV17.PDF
J27 = CON_MINIPCI_32X2: CON MINIPCI 2X32 1.00MM PITCH SOCKET ST TH; Chkd/date: MANIRAJA/101017; Crtd /date: MANIRAJA/101017; Custom_Duty: 24%; Customs_HS_Code: 85369090; Distributor_name: DIGIKEY; Distributor_part_number: SAM9742-ND; Height: 11.00MM; Mfr_name: SAMTEC; Mfr_part_number: PCIE-064-02-F-D-TH; Mistral Part No: 150017100015-R; Package: THRU-HOLE; Part_type: CONNECTOR\PCI; Project: TI_SVB_MAXWELL_SPM; RoHS: RoHS; TEXT: PCIe x2; Temperature: -55°C+125°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CONNECTORS\SAMTEC-PCIE-TH.PDF
J34 J35 = HEADER_3X1: HDR 1X3 2.54MM PITCH ST TH; Chkd/date: VASANTHA/290616; Crtd /date: VASANTHA/290616; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 609-3471-ND; Height: 8.58MM; Mfr_name: FCI; Mfr_part_number: 68001-403HLF; Mistral Part No: 150016060025-R; Package: THRU-HOLE; Part_type: CONNECTOR\HEADERS; Project: IKEYP; RoHS: RoHS; TEXT: REST; TEXT1: INT; TEXT2: EXT; Temperature: -40°C+105°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CONNECTORS\68000.PDF
R333 R346 = RESISTOR: RES 49.9E 1/16W 1% 0402; Chkd/date: MANIRAJA/210519; Crtd /date: MANIRAJA/210519; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 541-3967-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.35MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: VISHAY; Mfr_part_number: CRCW040249R9FKEDC; Mistral Part No: 110009030846-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: RFSU_RFTJ_CARD; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 1%; Voltage: NA; Wattage: 1/16W; Weight: 0.65mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\CRCW_C-SER.PDF
R338 = RESISTOR: RES 3.01K 1/16W 1% 0402; Chkd/date: MANIRAJA/150620; Crtd /date: ALVY/120620; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 541-3.01KLCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: VISHAY; Mfr_part_number: CRCW04023K01FKED; Mistral Part No: 110020060037-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: AM64x-GP_EVM BRD; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 1%; Voltage: NA; Wattage: 1/16W; Weight: 0.65mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\CRCW0603.PDF
R424 R430 R431 R482 R486 R576 = RESISTOR: RES 10K 1/16W 5% 0402; Chkd/date: VASANTHA/061216; Crtd /date: MAZHAR/230805; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-10KJRCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0402JR-0710KL; Mistral Part No: 110011060021-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: HSE; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 5%; Voltage: NA; Wattage: 1/16W; Weight: 0.65mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R437 R493 R632 R661 R662 R665-R668 R679 R680 = RESISTOR: RES 0E 1/16W JUMPER 0402; Chkd/date: VASANTHA/201216; Crtd /date: MUDDU/190810; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 541-0.0JCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: VISHAY; Mfr_part_number: CRCW04020000Z0ED; Mistral Part No: 110010080019-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: PB_BUGBASE; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: NA; Voltage: NA; Wattage: 1/16W; Weight: 0.65mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\CRCW0603.PDF
R622 R623 = RESISTOR: RES 1K 1/10W 1% 0402; Chkd/date: VASANTHA/281216; Crtd /date: MAZHAR/150506; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: P1.00KLCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: PANASONIC-ECG; Mfr_part_number: ERJ-2RKF1001X; Mistral Part No: 110009030411-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: VOCERA; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 1%; Voltage: NA; Wattage: 1/10W; Weight: 0.8mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\PAN-ERJSER_NOV17.PDF
R624 R625 = RESISTOR: RES 1.5K 1/16W 5% 0402; Chkd/date: MANIRAJA/310718; Crtd /date: BAVISH/021210; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-1.5KJRCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0402JR-071K5L; Mistral Part No: 110010120012-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: TE4; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 5%; Voltage: NA; Wattage: 1/16W; Weight: 0.65mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
TP83-TP85 TP94 TP95 = TESTPOINT: TESTPOINT CIR 20 SMD; Chkd/date: SHREESHAIL/171006; Crtd /date: MAZHAR/171006; Custom_Duty: NA; Customs_HS_Code: NA; Distributor_name: NA; Distributor_part_number: NA; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: NA; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; MECHANICAL 3D STEP FILE: NA; Mfr_name: LOCAL; Mistral Part No: NA; Package: SMD; Project: BT MODULE_CSRBC04; RoHS: NA; Temperature: NA; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: NA
U88 = SN74LVC1G08DBVRE4_SOT23-5: IC SINGLE 2-INPUT POSITIVE AND GATE SOT23-5; Chkd/date: SUHAS/221010; Crtd /date: USMAN/151008; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: SN74LVC1G08DBVRE4-ND; Height: 1.45MM; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 141009060026-R; Part_type: ICS\DIGITAL\GATES; Project: KHAN_MAIN; RoHS: Sb/ Br FREE; Temperature: -40°C+85°C; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\DIGITAL\GATES\SN74LVC1G08.PDF

## Nets
3V3_AUX: J27.B10(3.3VAUX) R493.2
DGND: C74.2 C75.2 C88.2 C91.2 C92.2 C93.2 C103.2 C120.2 C121.2 C289.2 C298.2 C299.2 C300.2 C322.2 C327.2 C340.2 C341.2 C344.2 C347.2 C348.2 C350.2 C353.2 C355.2 C356.2 C357.2 C358.2 C362.2 C363.2 C365.2 C368.2 C373.2 C375.2 C377.2 C380.2 C387.2 C390.2 C391.2 C396.2 C398.2 C399.2 C400.2 C426.2 C431.2 C432.2 C435.2 C436.2 C448.2 C449.2 C450.2 J27.A4(GND) J27.A12(GND) J27.A15(GND) J27.A18(GND) J27.A20(GND) J27.A23(GND) J27.A24(GND) J27.A27(GND) J27.A28(GND) J27.A31(GND) J27.B4(GND) J27.B7(GND) J27.B13(GND) J27.B16(GND) J27.B18(GND) J27.B21(GND) J27.B22(GND) J27.B25(GND) J27.B26(GND) J27.B29(GND) J27.B32(GND) R315.2 R333.2 R338.2 R346.2 R430.2 R437.1 R622.1 R623.1 U88.3(GND) ; also on sheet 2 3 6 7 8 9 10 11 12 13 14 15 16 17 18 19 20 21 22 23 24 25 26 27 28 29 30 39 40
VCC_3V3_SYS: C426.1 C435.1 C436.1 J27.A9(+3.3V) J27.A10(+3.3V) J27.B8(+3.3V) R424.1 R431.1 R482.2 R486.2 R493.1 R576.1 U88.5(VCC) ; also on sheet 2 6 7 8 10 11 12 13 14 15 16 17 18 19 20 21 23 24 25 26 27 29 30 39 40
VCC_5V0: R314.1 ; also on sheet 6 17 18 20 25
VDD_CORE: R78.1 R106.1 U23.J10(VDD_CORE) U23.J12(VDD_CORE) U23.K9(VDD_CORE) U23.K11(VDD_CORE) U23.L8(VDD_CORE) U23.L12(VDD_CORE) U23.M9(VDD_CORE) U23.M11(VDD_CORE) U23.N8(VDD_CORE) U23.N10(VDD_CORE) U23.P9(VDD_CORE) ; also on sheet 3 14 15 25
VDD_DDR4: U23.F7(VDDS_DDR) U23.G6(VDDS_DDR) U23.H7(VDDS_DDR) U23.J6(VDDS_DDR) U23.J8(VDDS_DDR_C) U23.K7(VDDS_DDR) U23.L6(VDDS_DDR) ; also on sheet 3 14 16 22
VDD_DLL_MMC0: C365.1 C373.1 C377.1 FB17.2 U23.H14(VDD_DLL_MMC0)
VDD_MMC1: U23.H15(VDDA_3P3_SDIO) ; also on sheet 3 24
VDDA_1V8: FB3.1 FB5.1 FB6.1 FB13.1 FB15.1 FB18.1 FB20.1 U23.G11(VDDA_TEMP0) U23.H13(VDDS_OSC) U23.L11(VDDA_TEMP1) ; also on sheet 3 14
VDDA_1V8_MCU: C103.1 C353.1 C387.1 FB5.2 U23.K12(VDDA_MCU)
VDDA_1V8_SERDES: C120.1 C121.1 C375.1 FB6.2 R632.2 U23.R14(VDDA_1P8_SERDES0)
VDDA_1V8_USB0: C380.1 C398.1 C399.1 FB20.2 U23.R15(VDDA_1P8_USB0)
VDDA_ADC: C363.1 C368.1 FB18.2 R699.2 U23.J13(VDDA_ADC) ; also on sheet 7
VDDA_CORE: FB4.1 FB16.1 FB17.1 R75.2 R78.2 U23.K13(VDD_MMC0)
VDDA_PLL0: C327.1 C340.1 C355.1 FB15.2 U23.N12(VDDA_PLL0)
VDDA_PLL1: C299.1 C300.1 C322.1 FB13.2 U23.H9(VDDA_PLL1)
VDDA_PLL2: C74.1 C75.1 C347.1 FB3.2 U23.J11(VDDA_PLL2)
VDDA_SYS_MON: R314.2 R315.1 R604.2 U23.K10(VMON_VSYS)
VDDAR_0P85_SERDES0: C88.1 C91.1 C92.1 C93.1 C344.1 C356.1 C362.1 FB4.2 U23.P11(VDDA_0P85_SERDES0_C) U23.P12(VDDA_0P85_SERDES0) U23.P13(VDDA_0P85_SERDES0)
VDDAR_0P85_USB0: C341.1 C350.1 C358.1 FB16.2 U23.T12(VDDA_0P85_USB0)
VDDAR_CORE: R75.1 R297.1 ; also on sheet 14 15
VDDR_CORE: R106.2 R297.2 U23.L10(VDDR_CORE) U23.M13(VDDR_CORE) ; also on sheet 3 25
VDDSHV_SD_IO: C400.1 U23.K15(CAP_VDDSHV_MMC1) U23.L14(VDDSHV5) U23.L15(VDDSHV5) ; also on sheet 3 24
CAP_VDDS0: C390.1 U23.H12(CAP_VDDS0)
CAP_VDDS1: C298.1 U23.T7(CAP_VDDS1)
CAP_VDDS2: C348.1 U23.R11(CAP_VDDS2)
CAP_VDDS3: C357.1 U23.N14(CAP_VDDS3)
CAP_VDDS4: C396.1 U23.M16(CAP_VDDS4)
CAP_VDDS5: C391.1 U23.L13(CAP_VDDS5)
CAP_VDDS_MCU: C289.1 U23.H10(CAP_VDDS_MCU)
CLKGEN_REFCLK1N: R661.1 ; also on sheet 11
CLKGEN_REFCLK1P: R662.1 ; also on sheet 11
CLKGEN_REFCLK4N: R667.1 ; also on sheet 11
CLKGEN_REFCLK4P: R668.1 ; also on sheet 11
GPIO_PCIe_RST_OUT: R424.2 R430.1 U88.1(A) ; also on sheet 13
PCIe_CLKREQn: J27.B12(RSVD4) R482.1
PCIe_MCU_PORz: J34.3 R576.2 ; also on sheet 12
PCIe_PRSNT1#: J27.A1(PRSNT1#) J35.3 R437.2
PCIe_PRSNT2#_1: J27.B17(PRSNT2#_1) J35.2
PCIe_PRSNT2n: J35.1 R431.2
PCIE_RESET_OUTn: J34.1 U88.4(Y)
PCIe_RESETn: J27.A11(PERST#) J34.2
PCIE_SERDES_REFCLK0_N: J27.A14(REFCLK-) R665.1 R667.2
PCIE_SERDES_REFCLK0_P: J27.A13(REFCLK+) R666.1 R668.2
PCIe_TCK: J27.A5(JTAG2) TP85.1(TP)
PCIe_TDI: J27.A6(JTAG3) TP83.1(TP)
PCIe_TDO: J27.A7(JTAG4) TP95.1(TP)
PCIe_TMS: J27.A8(JTAG5) TP84.1(TP)
PCIe_TRSTn: J27.B9(JTAG1) TP94.1(TP)
PCIe_WAKEn: J27.B11(WAKE#) R486.1
RESETSTATz: U88.2(B) ; also on sheet 11 12 13 21 24 29
SERDES0_REXT: R338.1 U23.T13(SERDES0_REXT)
SERDES_REFCLK0_N: R622.2 R624.2 R665.2 R680.1
SERDES_REFCLK0_N_C: R333.1 R661.2 R680.2 U23.W16(SERDES0_REFCLK0N)
SERDES_REFCLK0_P: R623.2 R625.2 R666.2 R679.1
SERDES_REFCLK0_P_C: R346.1 R662.2 R679.2 U23.W17(SERDES0_REFCLK0P)
SERDES_RXN0: J27.A17(PERn0) U23.Y15(SERDES0_RX0_N)
SERDES_RXP0: J27.A16(PERp0) U23.Y16(SERDES0_RX0_P)
SERDES_TXN0: C100.1 J27.B15(PETn0)
SERDES_TXN0_C: C100.2 U23.AA16(SERDES0_TX0_N)
SERDES_TXP0: C102.1 J27.B14(PETp0)
SERDES_TXP0_C: C102.2 U23.AA17(SERDES0_TX0_P)
SOC_DVDD1V8: R698.1 U23.E12(VMON_1P8_SOC) U23.K14(VDDS_MMC0) U23.K16(VMON_1P8_MCU) U23.M14(VDDSHV4) U23.M15(VDDSHV4) ; also on sheet 3 14
SoC_DVDD3V3: U23.F9(VDDSHV_MCU) U23.F11(VDDSHV0) U23.F13(VMON_3P3_MCU) U23.F14(VMON_3P3_SOC) U23.G8(VDDSHV_MCU) U23.G10(VDDSHV_MCU) U23.G12(VDDSHV0) U23.G14(VDDSHV0) U23.M7(VDDSHV1) U23.N6(VDDSHV1) U23.P7(VDDSHV1) U23.P14(VDDSHV3) U23.P15(VDDSHV3) U23.R8(VDDSHV2) U23.R10(VDDSHV2) U23.R13(VDDA_3P3_USB0) U23.T9(VDDSHV2) ; also on sheet 3 14
SoC_I2C1_SCL: J27.B5(SMCLK) ; also on sheet 6 7 10 11 13 14 30
SoC_I2C1_SDA: J27.B6(SMDAT) ; also on sheet 6 7 10 11 13 14 30
VDDS_MMC0/ADC0_VREFP: R698.2 R699.1 U23.J15(ADC0_REFP) ; also on sheet 9
VMAIN: C431.1 C432.1 C448.1 C449.1 C450.1 J27.A2(+12V) J27.A3(+12V) J27.B1(+12V) J27.B2(+12V) J27.B3(+12V) R604.1 ; also on sheet 8 16 17
VPP_1V8: U23.G15(VPP) ; also on sheet 15
N28887698: R624.1 R625.1 R632.1

Not connected (* = marked no-connect by the designer): J27 A19(RSVD1)* A21(PERp1)* A22(PERn1)* A25(PERp2)* A26(PERn2)* A29(PERp3)* A30(PERn3)* A32(RSVD2)* B19(PETp1)* B20(PETn1)* B23(PETp2)* B24(PETn2)* B27(PETp3)* B28(PETn3)* B30(RSVD3)* B31(PRSNT2#_2)*

## Notes on the sheets
sheet 4
- D-Note :-
  Recommend implementing the voltage monitoring functionality using VMON_VSYS for
  early detection of supply failure
  It is meant to be a  power-fail indicator for the main input (higher)  voltage
  rail that enters the PCB.  For example, 5, 12, or 24 volts.
  The error associated with this monitor would require you to set the threshold
  significantly lower than the nominal to avoid false trigger
  Refer System Power Supply Monitor Design Guidelines section of the data sheet
- SoC POWER
- D-Note :-
  Use 1%
  tolerance
  resistor
- D-Note :-
  Select a capacitor with ESR < 1 O.
  Ensure the PCB loop inductance is < 2.5 nH
  Select 0201 package or smallest possible package
  Refer SoC Data sheet
- D-Note :-
  Changing the core voltage is not
  allowed after the device has been
  released from reset. If you turn off
  the core supply, we expect you to
  turn off all power rails and ramp
  them down per the power-down
  sequence and wait until all supply
  rails decay below 300mv before
  turning on power again.
- D-Note :-
  VDDSHV_SD_IO
  Refer pin connectivity
  table when SD card
  interface is not used
- D-Note :-
  Add a filter cap Refer System Power
  Supply Monitor Design Guidelines
  section of SoC data sheet
- D-Note :-
  Increase voltage rating to
  10V or 16V to include the
  effect of DC bias
- D-Note :-
  VDDAR_0P85_SERDES0,
  VDDA_1V8_SERDES
  Refer usage note in the
  Pin connectivity  table
- D-Note :-
  VDDA_3P3_SDIO Connect to
  output of load switch when
  UHS-I speed is used
- R-Note
  Connecting 1.8V supply source
  directly to VPP continuously is
  not allowed
- R3
- R4
- R1
- R2
- CORE SUPPLY
- ARRAY CORE SUPPLY
- STEERING RESISTORS
- 0.75 VDD_CORE
- 0.85 VDDR_CORE&OTHERS
- R2 & R4 INSTALLED
- 0.85 VDD_CORE,VDDR_CORE&OTHERS
- NONE
- R1 & R3 INSTALLED
- D Note :-
  Mount R699 and DNI R698 when SR2.0 Device is used
  Mount R698 and DNI R699 when SR1.0 Device is used
  Currently shipped device are SR2.0
- D-Note :-
  Refer pin connectivity table of the SOC data sheet for connecting the USB IO, analog and core supplies
  when USB interface is not used. It is acceptable to have the supplies connected and all the USB pins left
  unconnected provided the USB driver is not initialized any time and the USB calibration procedure does not
  happen. Grounding the USB supplies as per pin connectivity requirements when not used saves power when low
  power is a critical requirement.
- D-Note :-
  A Trace connected to SOC  is effectively an antenna that will pick up noise.
  A potential will be generated on the signal when noise couples into the antenna.
  This potential will be largest on the highest impedance end of the signal.
  By placing a pull-up or pull-down near the SoC pin, we force the highest potential
  to the open-circuit end of the signal rather than the SoC end of the signal.
- CORE SUPPLY
- 1.8V Analog SUPPLY
- D-Note :-
  Bulk caps are optional
  when SERDES0 is not used
- D-Note :-
  Ferrite is optional
  when SERDES0 is not
  used
- D-Note :-
  Bulk caps are
  optional
  when SERDES0
  is not used
- 1.8V Analog SUPPLY
- D-Note :-
  Ferrite is optional
  when SERDES0 is not used
- D-Note :-
  Common SOC LVCMOS IO interface guidelines
  1. Most of the SOC IOs are not fail-safe. No input should be applied before supply ramps.
  2. SOC LVCMOS inputs have minimum slew rate requirements specified
  3. SOC IO buffers are off during Reset. A pull is required near to the attached device being driven by the SOC IOs
  4. Any SOC IO that has a trace connected  and not being actively driven needs a parallel pull. When adding pull is not feasible,
  ensure the traces are routed away from noisy signals
sheet 5
- x4 Lane PCIe Connector
- D-Note :-
  Errata i2326 PCIe refclk Applicable?
  i2326 does not apply when PCIe refclk
  is from an external source. It only
  applies if SK-AM64B is generating the
  refclk.
- Note:
  R679 , R680 Mounted with 0E Resistor when PCIe REFCLK is in no Re-biasing Mode.
  R679 , R680 to be replaced with 100nf CAP 0402 package when PCIe REFCLK is in
  Re-biasing Mode.
- CAD Note:
  Place Close to SoC
- D-Note :-
  SERDES0 inputs are not fail-safe.
  If clock or data inputs are available before the
  SOC supply ramps,  VDDR_CORE rail could be
  affected causing booting issues based on t
- PCIe Reset
- D-Note :-
  Add a series
  resistor to the GPIO
  input for isolation
  or testing
  Refer SK-AM62P-LP
  schematics
- D-Note :-
  Ok to use a 0201 resistor for the
  SERDES0_REXT given the power
  dissipation is around a mW
- CLOCK SELECTION
- CAD Note:
  Place Close to SoC
- CAD Note:
  Place Close to PCIe CON
- RC OR EP MODE SELECTION
- Off Page Connections
- Short 1 and  2 in J34& J35 for Host operation
  Short 3 and  2 in J34& J35 for Device operation
