# Allegro board PROC101D_BRD.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
R216  10E_1%  [RES0402_0-5#2]  149.29 121.17 270 bottom
R217  0E  [RES0402_0-5#2]  29.84 120.92 0 bottom
R218  10K  [RES0402_0-5#2]  57.55 120.17 180 bottom
R219  100K  [RES0402_0-5#2]  93.85 121.14 180 bottom
R220  0E  [RES0402_0-5#2]  24.51 120.14 90 bottom
R221  0E  [RES0402_0-5#2]  20.7 120.14 90 bottom
R222  0E  [RES0402_0-5#2]  14.6 120.14 90 bottom
R223  0E  [RES0402_0-5#2]  10.8 120.14 90 bottom
R224  10K  [RES0402_0-5#2]  112.85 119.19 90 bottom
R225  100K  [RES0402_0-5#2]  33.78 118.89 180 bottom
R226  10K  [RES0402_0-5#2]  102.69 118.3 270 bottom
R227  0.01E_0.5%  [RES1206-4TERM_0-75]  150.67 116.55 0 bottom
R228  10E_1%  [RES0402_0-5#2]  132.72 115.08 270 bottom
R229  10E_1%  [RES0402_0-5#2]  130.68 114.95 270 bottom
R230  0E  [RES0402_0-5]  28.01 114.57 0 bottom
R231  4.7K  [RES0402_0-5#2]  32.89 114.31 180 bottom
R232  10K_1%  [RES0402_0-5#2]  33.4 112.79 90 bottom
R233  0.01E_0.5%  [RES1206-4TERM_0-75]  131.62 112.23 180 bottom
R234  220E  [RES0402_0-5]  24.84 111.86 270 bottom
R235  22E_1%  [RES0402_0-5#2]  62.48 111.65 90 bottom
R236  22E_1%  [RES0402_0-5#2]  61.21 111.65 90 bottom
R237  22E_1%  [RES0402_0-5#2]  59.94 111.65 90 bottom
R238  22E_1%  [RES0402_0-5#2]  58.67 111.65 90 bottom
R239  22E_1%  [RES0402_0-5#2]  57.4 111.65 90 bottom
R240  10K  [RES0402_0-5#2]  43.05 111.65 90 bottom
R241  10K  [RES0402_0-5#2]  49.78 108.85 90 bottom
R242  10K  [RES0402_0-5#2]  48.51 108.85 90 bottom
R243  10K  [RES0402_0-5#2]  54.74 108.22 180 bottom
R244  0E  [RES0402_0-5#2]  145.54 108.09 180 bottom
R245  100E  [RES0402_0-5#2]  67.44 107.58 0 bottom
R246  0E  [RES0402_0-5#2]  64.39 107.33 270 bottom
R247  10K  [RES0402_0-5#2]  85.47 107.07 90 bottom
R248  10K  [RES0402_0-5#2]  54.74 106.95 0 bottom
R249  2.49K_1%  [RES0402_0-5#2]  43.64 106.95 90 bottom
R250  0E  [RES0402_0-5#2]  37.59 106.95 90 bottom
R251  2.49K_1%  [RES0402_0-5#2]  41.91 106.93 90 bottom
R252  0E  [RES0402_0-5#2]  68.58 105.79 180 bottom
R253  10K  [RES0402_0-5#2]  54.74 105.68 180 bottom
R254  0E  [RES0402_0-5#2]  64.9 105.42 180 bottom
R255  100E  [RES0402_0-5#2]  66.93 105.3 90 bottom
R256  39.2E_1%  [RES0402_0-5#2]  96.9 104.28 0 bottom
R257  100E  [RES0402_0-5#2]  64.9 104.15 0 bottom
R258  39.2E_1%  [RES0402_0-5#2]  84.08 103.65 180 bottom
R259  10K_1%  [RES0402_0-5#2]  171.96 103.39 180 bottom
R260  21K_1%  [RES0402_0-5#2]  175.39 103.14 0 bottom
R261  39.2E_1%  [RES0402_0-5#2]  96.9 103.01 0 bottom
R262  1K_1%  [RES0402_0-5#2]  64.9 102.88 180 bottom
R263  10K  [RES0402_0-5#2]  145.54 102.38 270 bottom
R264  39.2E_1%  [RES0402_0-5#2]  84.08 102.38 180 bottom
R265  4.7K  [RES0402_0-5#2]  134.49 102.25 0 bottom
R266  220K_1%  [RES0402_0-5#2]  175.39 101.87 180 bottom
R267  39.2E_1%  [RES0402_0-5#2]  96.9 101.74 0 bottom
R268  0E  [RES0402_0-5#2]  73.15 101.74 180 bottom
R269  39.2E_1%  [RES0402_0-5#2]  84.08 101.11 180 bottom
R270  4.7K  [RES0402_0-5#2]  134.49 100.98 0 bottom
R271  39.2E_1%  [RES0402_0-5#2]  97.03 100.47 0 bottom
R272  22E_1%  [RES0402_0-5#2]  64.77 100.34 0 bottom
R273  39.2E_1%  [RES0402_0-5#2]  84.08 99.84 180 bottom
R274  39.2E_1%  [RES0402_0-5#2]  97.03 99.2 0 bottom
R275  39.2E_1%  [RES0402_0-5#2]  84.08 98.57 180 bottom
R276  220E  [RES0402_0-5#2]  153.16 98.06 180 bottom
R277  51.1E_1%  [RES0402_0-5#2]  156.08 97.8 270 bottom
R278  10K  [RES0402_0-5#2]  56.26 96.27 180 bottom
R279  31.6K_1%  [RES0402_0-5#2]  156.08 95.9 270 bottom
R280  10E_1%  [RES0402_0-5#2]  138.94 95.9 270 bottom
R281  10E_1%  [RES0402_0-5#2]  137.41 95.9 270 bottom
R282  6.34K_1%  [RES0402_0-5#2]  127.76 95.9 270 bottom
R283  10K_1%  [RES0402_0-5#2]  126.49 95.9 90 bottom
R284  4.3K_1%  [RES0402_0-5#2]  125.22 95.9 270 bottom
R285  10K_1%  [RES0402_0-5#2]  129.41 95.65 0 bottom
R286  0E  [RES0402_0-5]  34.73 95.59 270 bottom
R287  39.2E_1%  [RES0402_0-5#2]  93.78 95.01 270 bottom
R288  39.2E_1%  [RES0402_0-5#2]  92.51 95.01 270 bottom
R289  39.2E_1%  [RES0402_0-5#2]  88.7 95.01 270 bottom
R290  39.2E_1%  [RES0402_0-5#2]  87.43 95.01 270 bottom
R291  39.2E_1%  [RES0402_0-5#2]  86.16 95.01 270 bottom
R292  10K  [RES0402_0-5#2]  56.26 95.01 0 bottom
R294  10K_1%  [RES0402_0-5#2]  156.08 93.99 270 bottom
R295  0.01E_0.5%  [RES1206-4TERM_0-75]  138.13 93.16 0 bottom
R297  0E  [RES1210_0-75]  118.21 90.79 270 top
R298  50E_0.1%  [RES0402_0-5#2]  109.4 97.76 270 bottom
R299  1M  [RES0603_0-75]  13.98 90.88 270 bottom
R300  10K  [RES0402_0-5#2]  26.99 90.1 0 bottom
R301  10K  [RES0402_0-5#2]  26.97 88.83 0 bottom
R302  22E_1%  [RES0402_0-5#2]  112.9 88.15 180 bottom
R303  4.7K  [RES0402_0-5#2]  112.9 86.88 180 bottom
R304  1M  [RES0603_0-75]  4.57 88.48 90 bottom
R305  220E  [RES0402_0-5#2]  135.18 86.28 0 bottom
R306  4.7K  [RES0402_0-5#2]  112.9 85.61 180 bottom
R307  50E_0.1%  [RES0402_0-5#2]  116.92 77.97 180 bottom
R308  2.49K_1%  [RES0402_0-5#2]  46.23 84.59 180 bottom
R309  4.7K  [RES0402_0-5#2]  112.9 84.34 180 bottom
R310  2.49K_1%  [RES0402_0-5#2]  46.23 83.45 180 bottom
R311  4.7K  [RES0402_0-5#2]  112.9 83.07 180 bottom
R312  0E  [RES0402_0-5#2]  134.34 81.28 0 bottom
R314  100K  [RES0402_0-5#2]  118.29 76.37 180 bottom
R315  11K_1%  [RES0402_0-5#2]  115.52 76.37 180 bottom
R317  10.2E_1%  [RES0402_0-5]  168.74 78.51 180 bottom
R318  10.2E_1%  [RES0402_0-5]  155.65 78.58 270 bottom
R319  10.2E_1%  [RES0402_0-5]  154.38 78.58 270 bottom
R320  240E_1%  [RES0402_0-5#2]  99.62 80.04 0 bottom
R321  10.2E_1%  [RES0402_0-5]  168.74 77.24 180 bottom
R322  4.7K  [RES0402_0-5#2]  98.81 77.87 90 bottom
R323  22E_1%  [RES0402_0-5#2]  101.6 77.23 180 bottom
R324  0E  [RES0402_0-5]  11.75 66.35 0 bottom
R325  1K_1%  [RES0402_0-5#2]  70.87 75.2 270 bottom
R326  1K_1%  [RES0402_0-5#2]  69.6 75.2 270 bottom
R327  1K_1%  [RES0402_0-5#2]  68.33 75.2 270 bottom
R328  1K_1%  [RES0402_0-5#2]  67.06 75.2 270 bottom
R329  1K_1%  [RES0402_0-5#2]  65.79 75.2 270 bottom
R330  1K_1%  [RES0402_0-5#2]  64.52 75.2 270 bottom
R331  1K_1%  [RES0402_0-5#2]  63.25 75.2 270 bottom
R332  1K_1%  [RES0402_0-5#2]  61.98 75.2 270 bottom
R333  49.9E_1%  [RES0402_0-5#2]  78.7 74.86 90 bottom
R334  0E  [RES0402_0-5]  1.93 69.85 0 bottom
R336  220E  [RES0402_0-5#2]  5.55 74.85 0 bottom
R338  3.01K_1%  [RES0402_0-5#2]  73.41 74.27 270 bottom
R340  2.49K_1%  [RES0402_0-5#2]  42.16 71.51 270 bottom
R341  2.49K_1%  [RES0402_0-5#2]  41.15 71.51 90 bottom
R343  0E  [RES0402_0-5]  2.06 75.75 0 bottom
R344  10K  [RES0402_0-5#2]  104.78 70.5 180 bottom
R345  0E  [RES0402_0-5#2]  100.46 69.85 270 bottom
R346  49.9E_1%  [RES0402_0-5#2]  78.7 70.54 270 bottom
R347  220E  [RES0402_0-5#2]  5.54 76.96 0 bottom
R348  10K  [RES0402_0-5#2]  104.78 69.23 180 bottom
R349  11K_1%  [RES0402_0-5]  33.78 69 0 bottom
R350  10E_1%  [RES0402_0-5#2]  133.99 68.34 180 bottom
R351  0.01E_0.5%  [RES1206-4TERM_0-75]  131.12 67.62 90 bottom
R352  10E_1%  [RES0402_0-5#2]  133.99 66.94 180 bottom
R353  4.7K  [RES0402_0-5#2]  125.28 66.82 180 bottom
R354  4.7K  [RES0402_0-5#2]  110.62 66.69 180 bottom
R355  10K  [RES0402_0-5#2]  71.63 66.69 270 bottom
R356  10K  [RES0402_0-5#2]  70.36 66.69 90 bottom
R357  4.7K  [RES0402_0-5#2]  125.28 65.55 180 bottom
R358  4.7K  [RES0402_0-5#2]  110.62 65.42 180 bottom
R359  2.49K_1%  [RES0402_0-5#2]  44.58 64.67 0 bottom
R360  220E  [RES0402_0-5#2]  138.81 63.77 90 bottom
R361  7.5K_1%  [RES0402_0-5#2]  18.67 63.77 270 bottom
R362  220E  [RES0402_0-5#2]  171.7 63.64 0 bottom
R363  2.49K_1%  [RES0402_0-5#2]  44.58 63.52 0 bottom
R364  21K_1%  [RES0402_0-5#2]  19.18 62.12 0 bottom
R365  220E  [RES0402_0-5#2]  7.15 61.46 270 bottom
R366  2.49K_1%  [RES0402_0-5#2]  44.33 61.61 180 bottom
R367  10K  [RES0402_0-5#2]  27.81 60.85 180 bottom
R368  2.2K  [RES0402_0-5]  37.34 60.6 270 bottom
R369  10K  [RES0402_0-5]  38.58 60.59 90 bottom
R370  1.5K  [RES0402_0-5#2]  39.92 60.53 270 bottom
R371  10K  [RES0402_0-5#2]  30.48 60.21 180 bottom
R372  1K_1%  [RES0402_0-5#2]  78.23 59.58 270 bottom
R373  1K_1%  [RES0402_0-5#2]  76.96 59.58 270 bottom
R374  1K_1%  [RES0402_0-5#2]  75.69 59.58 270 bottom
R375  1K_1%  [RES0402_0-5#2]  74.42 59.58 270 bottom
R376  1K_1%  [RES0402_0-5#2]  73.15 59.58 270 bottom
R377  1K_1%  [RES0402_0-5#2]  71.88 59.58 270 bottom
R378  1K_1%  [RES0402_0-5#2]  70.61 59.58 270 bottom
R379  1K_1%  [RES0402_0-5#2]  69.34 59.58 270 bottom
R380  10K  [RES0402_0-5#2]  30.48 58.94 180 bottom
R381  220E  [RES0402_0-5#2]  51.99 69.76 90 bottom
R382  220E  [RES0402_0-5#2]  49.96 69.76 90 bottom
R383  220E  [RES0402_0-5#2]  22.53 88.41 90 bottom
R384  220E  [RES0402_0-5#2]  20.5 88.41 90 bottom
R385  2.49K_1%  [RES0402_0-5#2]  37.34 58.19 270 bottom
R386  2.49K_1%  [RES0402_0-5#2]  36.32 58.19 270 bottom
R387  2.49K_1%  [RES0402_0-5#2]  38.35 58.12 90 bottom
R388  2.49K_1%  [RES0402_0-5#2]  35.31 58.12 90 bottom
R389  22E_1%  [RES0402_0-5#2]  93.21 57.46 90 bottom
R390  0E  [RES0402_0-5#2]  91.94 57.46 270 bottom
R391  0E  [RES0402_0-5#2]  90.67 57.46 270 bottom
R392  0E  [RES0402_0-5#2]  89.4 57.46 270 bottom
R393  0E  [RES0402_0-5#2]  88.11 57.46 270 bottom
R394  10K  [RES0402_0-5#2]  117.53 57.16 0 bottom
R395  10K  [RES0402_0-5#2]  115.39 57.16 180 bottom
R396  100K  [RES0402_0-5#2]  17.53 56.28 270 bottom
R397  10K  [RES0402_0-5#2]  140.59 55.89 0 bottom
R398  10K  [RES0402_0-5#2]  119.25 55.38 90 bottom
R399  10K  [RES0402_0-5#2]  113.67 55.38 90 bottom
R400  10K  [RES0402_0-5#2]  132.97 54.75 270 bottom
R401  10K  [RES0402_0-5#2]  33.65 40.32 90 top
R402  10K  [RES0402_0-5#2]  36.83 39.86 90 top
R403  10K  [RES0402_0-5#2]  139.19 54.62 180 bottom
R404  22E_1%  [RES0402_0-5#2]  104.27 54.44 90 bottom
R405  10K  [RES0402_0-5#2]  105.54 54.37 270 bottom
R406  10K  [RES0402_0-5#2]  132.08 53.1 180 bottom
R407  220E  [RES0402_0-5#2]  161.8 52.97 0 bottom
R408  100K  [RES0402_0-5#2]  170.94 52.08 0 bottom
R409  0E  [RES0402_0-5#2]  64.64 50.69 270 bottom
R410  10E_1%  [RES0402_0-5#2]  63.37 50.69 90 bottom
R411  100E  [RES0402_0-5#2]  62.36 50.69 90 bottom
R412  0E  [RES0402_0-5#2]  170.94 49.93 0 bottom
R413  10K  [RES0402_0-5#2]  36.53 50.88 0 top
R414  10K  [RES0402_0-5#2]  106.64 48.66 180 bottom
R416  10K  [RES0402_0-5#2]  33.53 45.48 0 bottom
R417  10K_1%  [RES0402_0-5#2]  129.54 45.23 270 bottom
R418  220E  [RES0402_0-5#2]  30.25 74 90 bottom
R419  220E  [RES0402_0-5#2]  32.28 74 90 bottom
R420  220E  [RES0402_0-5#2]  34.82 74.03 90 bottom
R421  220E  [RES0402_0-5#2]  36.35 74.03 90 bottom
R422  0E  [RES0402_0-5#2]  96.39 44.59 0 bottom
R423  0E  [RES0402_0-5#2]  103.5 44.46 0 bottom
R424  10K  [RES0402_0-5#2]  35.18 43.19 0 bottom
R425  0E  [RES0402_0-5#2]  103.5 43.07 0 bottom
R426  10K  [RES0402_0-5#2]  30.15 42.56 180 bottom
R427  16.5K_0.1%  [RES0402_0-5#2]  5.46 42.18 0 bottom
R428  3.48K_0.1%  [RES0402_0-5#2]  3.43 42.18 0 bottom
R429  10K  [RES0402_0-5#2]  109.52 42.05 0 bottom
R430  10K  [RES0402_0-5#2]  35.18 41.92 180 bottom
R431  10K_1%  [RES0402_0-5#2]  19.3 41.8 270 bottom
R432  0E  [RES0402_0-5#2]  103.5 41.67 0 bottom
R433  0E  [RES0402_0-5#2]  93.85 40.78 180 bottom
R434  0E  [RES0402_0-5#2]  109.47 40.53 0 bottom
R435  0E  [RES0402_0-5#2]  107.44 40.53 180 bottom
R436  10K_1%  [RES0402_0-5#2]  7.87 38.75 90 bottom
R437  0E  [RES0402_0-5#2]  31.37 40.72 180 bottom
R438  10K  [RES0402_0-5#2]  155.07 38.11 0 bottom
R439  10K  [RES0402_0-5#2]  111 38.11 270 bottom
R440  0E  [RES0402_0-5#2]  100.35 38.11 270 bottom
R441  0E  [RES0402_0-5#2]  99.08 38.11 270 bottom
R442  0E  [RES0402_0-5#2]  97.81 38.11 270 bottom
R443  0E  [RES0402_0-5#2]  96.54 38.11 270 bottom
R444  10K  [RES0402_0-5#2]  116.13 37.59 270 bottom
R445  10K  [RES0402_0-5#2]  153.42 37.1 90 bottom
R446  0E  [RES0402_0-5#2]  114.24 37.1 0 bottom
R447  100E  [RES0402_0-5#2]  68.07 36.72 90 bottom
R448  100E  [RES0402_0-5#2]  66.8 36.72 90 bottom
R449  10E_1%  [RES0402_0-5#2]  65.53 36.72 90 bottom
R450  10E_1%  [RES0402_0-5#2]  64.26 36.72 90 bottom
R451  10E_1%  [RES0402_0-5#2]  62.99 36.72 90 bottom
R452  10K  [RES0402_0-5#2]  59.82 34.94 270 bottom
R453  10K  [RES0402_0-5#2]  108.71 34.81 0 bottom
R454  0E  [RES0402_0-5#2]  106.68 34.81 180 bottom
R455  4.7K  [RES0402_0-5#2]  94.92 34.76 0 bottom
R456  49.9K_1%  [RES0402_0-5#2]  118.79 34.48 180 bottom
R457  49.9K_1%  [RES0402_0-5#2]  116.64 34.48 0 bottom
R458  4.7K  [RES0402_0-5#2]  99.39 34.48 180 bottom
R459  10K  [RES0402_0-5#2]  94.64 33.29 90 bottom
R460  4.7K  [RES0402_0-5#2]  97.94 33.23 270 bottom
R461  4.7K  [RES0402_0-5#2]  96.63 33.23 270 bottom
R462  220E  [RES0402_0-5#2]  141.31 32.53 0 bottom
R463  10K  [RES0402_0-5#2]  133.6 32.15 180 bottom
R464  220E  [RES0402_0-5#2]  137.03 31.38 270 bottom
R465  10K  [RES0402_0-5#2]  59.94 30.37 0 bottom
R466  180E  [RES0402_0-5#2]  141.44 30.24 0 bottom
R467  100E  [RES0402_0-5#2]  162.22 30.24 270 bottom
R468  220K_1%  [RES0402_0-5#2]  144.91 30.24 90 bottom
R469  330K_1%  [RES0402_0-5#2]  143.68 30.24 270 bottom
R470  0E  [RES0402_0-5#2]  122.89 30 0 bottom
R471  0E  [RES0402_0-5#2]  122.9 28.73 0 bottom
R472  1K_1%  [RES0402_0-5#2]  92.07 29.52 90 bottom
R473  100K  [RES0402_0-5#2]  104.24 24.48 90 bottom
R474  100K  [RES0402_0-5#2]  90.78 24.51 90 bottom
R475  1K_1%  [RES0402_0-5#2]  102.95 29.52 90 bottom
R476  10K  [RES0402_0-5#2]  125.6 27.57 0 bottom
R477  10K  [RES0402_0-5#2]  122.94 27.45 180 bottom
R478  0E  [RES0402_0-5#2]  160.7 27.44 0 bottom
R479  10K  [RES0402_0-5#2]  38.1 26.68 270 bottom
R480  10K  [RES0402_0-5#2]  36.83 26.68 270 bottom
R481  10K  [RES0402_0-5#2]  35.31 26.68 270 bottom
R482  10K  [RES0402_0-5#2]  23.88 26.68 0 bottom
R483  10K  [RES0402_0-5#2]  45.29 26.56 270 bottom
R484  10K  [RES0402_0-5#2]  43.94 26.56 270 bottom
R485  10K  [RES0402_0-5#2]  42.55 26.56 270 bottom
R486  10K  [RES0402_0-5#2]  20.7 26.56 0 bottom
R487  1K_1%  [RES0402_0-5#2]  90.8 29.52 90 bottom
R488  100K  [RES0402_0-5#2]  104.22 22.07 90 bottom
R489  100K  [RES0402_0-5#2]  90.8 22.07 90 bottom
R490  1K_1%  [RES0402_0-5#2]  104.22 29.52 90 bottom
R491  33E_1%  [RES0402_0-5#2]  81.05 26.53 270 bottom
R492  33E_1%  [RES0402_0-5#2]  75.46 25.17 90 bottom
R493  0E  [RES0402_0-5#2]  18.29 26.43 0 bottom
R494  4.7K  [RES0402_0-5#2]  67.01 25.81 90 bottom
R495  4.7K  [RES0402_0-5#2]  65.68 25.81 90 bottom
R496  1K_1%  [RES0402_0-5#2]  89.53 29.52 90 bottom
R497  100K  [RES0402_0-5#2]  105.49 22.07 90 bottom
R498  100K  [RES0402_0-5#2]  89.53 22.07 90 bottom
R499  1K_1%  [RES0402_0-5#2]  105.49 29.52 90 bottom
R500  0E  [RES0402_0-5#2]  59.05 25.03 270 bottom
R501  1K_1%  [RES0402_0-5#2]  88.27 29.52 90 bottom
R502  100K  [RES0402_0-5#2]  106.76 22.07 90 bottom
R503  100K  [RES0402_0-5#2]  88.27 22.07 90 bottom
R504  1K_1%  [RES0402_0-5#2]  106.76 29.52 90 bottom
R505  4.7K  [RES0402_0-5#2]  141.35 23.64 90 bottom
R506  22E_1%  [RES0402_0-5#2]  126.82 59.88 90 bottom
R507  10K  [RES0402_0-5#2]  124.64 59.63 270 bottom
R508  1K_1%  [RES0402_0-5#2]  87 29.52 90 bottom
R509  100K  [RES0402_0-5#2]  108.03 22.07 90 bottom
R510  100K  [RES0402_0-5#2]  87 22.07 90 bottom
R511  1K_1%  [RES0402_0-5#2]  108.03 29.52 90 bottom
R512  1K_1%  [RES0402_0-5#2]  85.73 29.52 90 bottom
R513  100K  [RES0402_0-5#2]  109.3 22.07 90 bottom
R514  100K  [RES0402_0-5#2]  85.73 22.07 90 bottom
R515  1K_1%  [RES0402_0-5#2]  109.3 29.52 90 bottom
R516  100K  [RES0402_0-5#2]  26.8 21.01 270 bottom
R517  1K_1%  [RES0402_0-5#2]  84.46 29.52 90 bottom
R518  100K  [RES0402_0-5#2]  110.57 22.07 90 bottom
R519  100K  [RES0402_0-5#2]  84.46 22.07 90 bottom
R520  1K_1%  [RES0402_0-5#2]  110.57 29.52 90 bottom
R521  10K  [RES0402_0-5#2]  72.62 19.44 90 bottom
R522  10K  [RES0402_0-5#2]  71.47 19.44 90 bottom
R523  10K  [RES0402_0-5#2]  70.33 19.44 90 bottom
R524  10K  [RES0402_0-5#2]  69.19 19.44 90 bottom
R525  10K  [RES0402_0-5#2]  68.05 19.44 90 bottom
R526  10K  [RES0402_0-5#2]  66.9 19.44 90 bottom
R527  1K_1%  [RES0402_0-5#2]  83.19 29.52 90 bottom
R528  100K  [RES0402_0-5#2]  111.84 22.07 90 bottom
R529  100K  [RES0402_0-5#2]  83.19 22.07 90 bottom
R530  1K_1%  [RES0402_0-5#2]  111.84 29.52 90 bottom
R531  10K  [RES0402_0-5#2]  9.13 18.94 180 bottom
R532  10K  [RES0402_0-5#2]  98.41 18.68 180 bottom
R533  10K  [RES0402_0-5#2]  94.48 18.68 180 bottom
R534  10K  [RES0402_0-5#2]  125.09 18.05 270 bottom
R535  100K  [RES0402_0-5#2]  59.44 18.05 270 bottom
R536  10K  [RES0402_0-5#2]  130.94 17.9 270 bottom
R537  10K  [RES0402_0-5#2]  117.29 17.86 270 bottom
R538  4.7K  [RES0402_0-5#2]  28.32 17.7 90 bottom
R540  10K  [RES0402_0-5#2]  139.84 17.47 270 bottom
R541  820K_1%  [RES0402_0-5#2]  10.16 17.29 180 bottom
R542  0E  [RES0402_0-5#2]  73.76 17.03 270 bottom
R543  0E  [RES0402_0-5#2]  72.62 17.03 270 bottom
R544  0E  [RES0402_0-5#2]  71.47 17.03 270 bottom
R545  0E  [RES0402_0-5#2]  70.33 17.03 270 bottom
R546  0E  [RES0402_0-5#2]  69.19 17.03 270 bottom
R547  0E  [RES0402_0-5#2]  68.05 17.03 270 bottom
R548  0E  [RES0402_0-5#2]  66.9 17.03 270 bottom
R549  10K  [RES0402_0-5#2]  102.97 16.91 270 bottom
R550  4.7K  [RES0402_0-5#2]  65.66 16.78 270 bottom
R551  4.7K  [RES0402_0-5#2]  64.26 16.78 270 bottom
R552  0E  [RES0402_0-5#2]  93.12 16.17 270 bottom
R553  0E  [RES0402_0-5#2]  102.97 14.49 90 bottom
R554  10K  [RES0402_0-5#2]  93.12 13.76 90 bottom
R555  1K_1%  [RES0402_0-5#2]  56.77 12.46 180 bottom
R556  160E_1%  [RES0402_0-5#2]  16.51 10.68 0 bottom
R557  1K_1%  [RES0402_0-5#2]  160.32 10.3 270 bottom
R558  1K_1%  [RES0402_0-5#2]  159.05 10.3 270 bottom
R559  1K_1%  [RES0402_0-5#2]  157.78 10.3 270 bottom
R560  1K_1%  [RES0402_0-5#2]  156.51 10.3 270 bottom
R561  30K  [RES0402_0-5#2]  163.45 9.54 0 bottom
R562  2.49K_1%  [RES0402_0-5#2]  32.74 58.16 90 bottom
R563  2.49K_1%  [RES0402_0-5#2]  34.04 58.16 270 bottom
R564  2.49K_1%  [RES0402_0-5#2]  32.89 90.34 270 top
R565  2.49K_1%  [RES0402_0-5#2]  34.16 90.34 90 top
R566  1M  [RES0603_0-75]  170.38 108.85 270 bottom
R574  10K  [RES0402_0-5#2]  129.02 54.24 180 top
R575  10K  [RES0402_0-5#2]  124.57 50.02 90 top
R576  10K_1%  [RES0402_0-5#2]  47.88 45.21 270 bottom
R577  0E  [RES0402_0-5#2]  165.65 56.08 90 top
R578  0E  [RES0402_0-5#2]  158.77 56.07 270 top
R579  0E  [RES0402_0-5#2]  140.48 96.22 90 top
R580  0E  [RES0402_0-5#2]  146.56 120.78 90 bottom
R581  0E  [RES0402_0-5#2]  96.52 119.25 270 bottom
R582  0E  [RES0402_0-5#2]  144.15 102.38 270 bottom
R583  0E  [RES0402_0-5#2]  139.45 55.39 0 top
R584  0E  [RES0402_0-5#2]  135.27 73.44 270 top
R585  0E  [RES0402_0-5#2]  32.89 117.22 180 bottom
R586  0E  [RES0402_0-5#2]  89.39 131.7 90 bottom
R587  0E  [RES0402_0-5#2]  19.3 59.18 0 bottom
R588  0E  [RES0402_0-5#2]  47.12 95.38 90 bottom
R589  0E  [RES0402_0-5#2]  13.46 18.67 180 bottom
R591  0E  [RES0402_0-5#2]  88.01 66.04 0 bottom
R593  620E_1%  [RES0402_0-5#2]  112.9 81.8 180 bottom
R594  620E_1%  [RES0402_0-5#2]  110.22 85.3 270 bottom
R597  620E_1%  [RES0402_0-5#2]  99.42 64.13 90 bottom
R598  620E_1%  [RES0402_0-5#2]  103.9 67.46 90 bottom
R599  620E_1%  [RES0402_0-5#2]  106.7 66.94 90 bottom
R600  0E  [RES0402_0-5#2]  98.48 50.21 90 top
R602  10K  [RES0402_0-5#2]  141.97 96.22 270 top
R604  255K_1%  [RES0402_0-5#2]  118.36 75.06 180 bottom
R605  499E_1%  [RES0402_0-5#2]  73.33 72.75 180 bottom
R606  4.7K  [RES0402_0-5#2]  117.32 65.98 0 top
R608  4.7K  [RES0402_0-5#2]  134.98 54.91 0 bottom
R609  4.7K  [RES0402_0-5#2]  151.76 35.56 0 bottom
R610  4.7K  [RES0402_0-5#2]  151.05 36.88 0 bottom
R611  4.7K  [RES0402_0-5#2]  143.48 57.45 180 bottom
R612  220E  [RES0402_0-5#2]  6.56 86.72 90 top
R613  220E  [RES0402_0-5#2]  12.95 86.74 90 top
R614  0E  [RES0402_0-5#2]  16.98 89.76 0 top
R615  220E  [RES0402_0-5#2]  3.25 80.64 180 bottom
R616  220E  [RES0402_0-5#2]  14.94 82.25 0 bottom
R617  0E  [RES0402_0-5#2]  16.33 87.17 0 bottom
R622  1K_1%  [RES0402_0-5#2]  77.43 75.12 270 bottom
R623  1K_1%  [RES0402_0-5#2]  77.43 70.54 90 bottom
R624  1.5K  [RES0402_0-5#2]  76.16 75.12 270 bottom
R625  1.5K  [RES0402_0-5#2]  76.16 70.54 90 bottom
R630  1K_1%  [RES0402_0-5#2]  161.19 41.61 90 top
R631  1K_1%  [RES0402_0-5#2]  166.4 41.61 90 top
R632  0E  [RES0402_0-5#2]  80.32 68.66 0 bottom
R634  10K  [RES0402_0-5#2]  161.17 44.15 90 top
R635  10K  [RES0402_0-5#2]  166.4 44.15 90 top
R636  100E  [RES0402_0-5#2]  82.35 25.43 270 bottom
R637  10K  [RES0402_0-5#2]  82.84 27.02 0 bottom
R638  100E  [RES0402_0-5#2]  75.46 19.15 270 bottom
R639  10K  [RES0402_0-5#2]  74.97 20.85 180 bottom
R640  10K  [RES0402_0-5#2]  86.26 44.3 0 bottom
R641  10K  [RES0402_0-5#2]  62.99 36.72 270 top
R642  10K  [RES0402_0-5#2]  61.98 51.28 0 top
R643  10K  [RES0402_0-5#2]  86.26 44.3 0 top
R644  10K  [RES0402_0-5#2]  104.76 53.95 0 top
R645  10K  [RES0402_0-5#2]  94.67 57.46 90 bottom
R646  10K  [RES0402_0-5#2]  47.65 30.2 0 bottom
R652  33E_1%  [RES0402_0-5#2]  47.12 54.19 180 top
R653  33E_1%  [RES0402_0-5#2]  47.12 55.2 180 top
R654  33E_1%  [RES0402_0-5#2]  55.14 55.2 0 top
R655  33E_1%  [RES0402_0-5#2]  55.14 54.19 0 top
R656  4.7K  [RES0402_0-5#2]  50.95 52.66 180 bottom
R659  0E  [RES0402_0-5#2]  55.14 57.23 180 top
R660  0E  [RES0402_0-5#2]  46.91 56.73 0 top
R661  0E  [RES0402_0-5#2]  79.19 73.39 180 bottom
R662  0E  [RES0402_0-5#2]  79.19 72.02 180 bottom
R665  0E  [RES0402_0-5#2]  25.86 38.1 0 bottom
R666  0E  [RES0402_0-5#2]  25.86 39.4 0 bottom
R667  0E  [RES0402_0-5#2]  25.86 38.1 180 top
R668  0E  [RES0402_0-5#2]  25.86 39.4 180 top
R672  4.7K  [RES0402_0-5#2]  55.14 56.22 180 top
R679  0E  [RES0402_0-5#2]  78.21 72.07 0 bottom
R680  0E  [RES0402_0-5#2]  78.21 73.34 0 bottom
R681  49.9E_1%  [RES0402_0-5#2]  45.47 53.68 270 top
R682  49.9E_1%  [RES0402_0-5#2]  45.47 55.71 90 top
R683  49.9E_1%  [RES0402_0-5#2]  56.79 55.71 90 top
R684  49.9E_1%  [RES0402_0-5#2]  56.79 53.68 270 top
R685  100E  [RES0402_0-5#2]  77.67 41.48 0 top
R686  4.7K  [RES0402_0-5#2]  43.21 54.95 270 top
R687  4.7K  [RES0402_0-5#2]  42.19 54.95 90 top
R688  0E  [RES0402_0-5#2]  49.17 55.71 90 bottom
R693  0E  [RES0402_0-5#2]  160.67 54.07 0 top
R694  0E  [RES0402_0-5#2]  161.65 54.07 0 top
R695  2.2E  [RES0603_0-75]  155.11 60.69 0 top
R696  1K_1%  [RES0402_0-5#2]  119.77 103.45 90 top
R697  0E  [RES0402_0-5#2]  136.49 73.43 270 top
R698  0E  [RES0201_0-5]  100 68.09 0 bottom
R699  0E  [RES0201_0-5]  99.99 67.27 180 bottom
R700  0E  [RES0402_0-5#2]  164.48 56.08 270 top
R701  0E  [RES0402_0-5#2]  163.36 56.08 90 top
RA1  0E  [RESA_EXB2HV_0602-8_0-6]  65.95 78.63 0 top
RA2  0E  [RESA_EXB2HV_0602-8_0-6]  65.95 73.9 180 top
RA3  0E  [RESA_EXB2HV_0602-8_0-6]  73.32 63.01 0 top
RA4  0E  [RESA_EXB2HV_0602-8_0-6]  73.32 58.28 180 top
RA5  0E  [RESA_EXB2HV_0602-8_0-6]  84.58 62.24 180 bottom
RA6  0E  [RESA_EXB2HV_0602-8_0-6]  84.58 58.41 0 bottom
SW1  ATE1D-6M3-10-Z  [SW3_ATE1F-6M3_370X710_TH_5-6]  168.28 54.62 90 top
SW2  218-8LPSTR  [SW8_218-8LPST_450X230_SMD_2-7]  87.63 25.8 0 top
SW3  218-8LPSTR  [SW8_218-8LPST_450X230_SMD_2-7]  107.39 25.8 0 top
SW4  SKHMQLE010  [SW4_SKHMQLE010_240X260_SMD_3-1]  116.99 13.71 90 top
SW5  SKHMQLE010  [SW4_SKHMQLE010_240X260_SMD_3-1]  124.28 13.71 90 top
SW6  SKHMQLE010  [SW4_SKHMQLE010_240X260_SMD_3-1]  131.58 13.71 90 top
SW7  SKHMQLE010  [SW4_SKHMQLE010_240X260_SMD_3-1]  138.89 13.57 90 top
TP1  -  [TP20_SMD]  164.59 126.51 90 top
TP2  5002  [TP_CIR67D40_TH_4-6]  157.12 114.98 0 top
TP3  5002  [TP_CIR67D40_TH_4-6]  154.69 125.11 0 top
TP4  THRU HOLE  [TP_40X65]  91.57 116.57 90 top
TP5  5002  [TP_CIR67D40_TH_4-6]  17.53 114.7 0 top
TP6  THRU HOLE  [TP_40X65]  38.61 112.54 0 top
TP7  -  [TP20_SMD]  77.98 111.14 90 top
TP8  THRU HOLE  [TP_40X65]  152.53 108.73 90 top
TP9  -  [TP20_SMD]  34.29 107.33 0 top
TP10  THRU HOLE  [TP_40X65]  149.61 106.19 90 top
TP11  -  [TP20_SMD]  32.89 106.12 0 top
TP12  THRU HOLE  [TP_40X65]  152.78 100.6 0 top
TP13  -  [TP20_SMD]  94.87 87.5 180 bottom
TP14  THRU HOLE  [TP_40X65]  123.22 95.93 90 top
TP15  -  [TP20_SMD]  97.03 94.63 0 top
TP16  -  [TP20_SMD]  38.99 93.87 0 top
TP17  -  [TP20_SMD]  40.77 89.81 0 top
TP18  THRU HOLE  [TP_40X65]  175.14 87.02 270 top
TP19  -  [TP20_SMD]  33.66 86.37 0 top
TP20  -  [TP20_SMD]  70.76 86.11 180 bottom
TP21  -  [TP20_SMD]  71.91 84.42 0 top
TP22  -  [TP20_SMD]  70.52 83.75 0 top
TP23  THRU HOLE  [TP_40X65]  128.57 82.98 90 top
TP24  -  [TP20_SMD]  135.27 71.66 90 top
TP25  -  [TP20_SMD]  123.57 70.5 180 top
TP26  5002  [TP_CIR67D40_TH_4-6]  143.99 62.42 0 top
TP27  -  [TP20_SMD]  125.22 64.78 180 top
TP28  THRU HOLE  [TP_40X65]  14.99 64.02 180 top
TP29  THRU HOLE  [TP_40X65]  131.11 59.45 0 top
TP30  -  [TP20_SMD]  97.29 58.94 0 top
TP31  5002  [TP_CIR67D40_TH_4-6]  50.39 12.41 0 top
TP32  -  [TP20_SMD]  142.88 41.62 90 top
TP33  -  [TP20_SMD]  122.95 51.35 0 top
TP34  5002  [TP_CIR67D40_TH_4-6]  165.99 29.99 0 top
TP35  -  [TP20_SMD]  157.9 32.78 180 top
TP36  -  [TP20_SMD]  159.68 33.13 180 top
TP37  -  [TP20_SMD]  156.51 32.78 180 top
TP38  -  [TP20_SMD]  159.68 32.02 180 top
TP39  -  [TP20_SMD]  34.16 25.92 0 top
TP40  -  [TP20_SMD]  66.93 18.94 0 top
TP41  -  [TP20_SMD]  68.33 18.94 0 top
TP42  -  [TP20_SMD]  97.03 18.02 0 top
TP43  -  [TP20_SMD]  64.14 15.76 0 top
TP44  THRU HOLE  [TP_40X65]  145.29 11.19 0 top
TP45  -  [TP20_SMD]  87.63 132.09 90 bottom
TP46  -  [TP20_SMD]  123.72 25.52 0 top
TP47  THRU HOLE  [TP_40X65]  91.57 123.84 90 top
TP48  THRU HOLE  [TP_40X65]  78.21 122.11 270 top
TP49  -  [TP20_SMD]  146.56 122.44 270 bottom
TP50  -  [TP20_SMD]  147.45 118.76 270 bottom
TP51  THRU HOLE  [TP_40X65]  137.79 111.39 270 top
TP52  THRU HOLE  [TP_40X65]  140.46 103.14 270 top
TP53  -  [TP20_SMD]  145.16 100.73 270 bottom
TP54  THRU HOLE  [TP_40X65]  105.77 95.6 270 top
TP55  THRU HOLE  [TP_40X65]  105.84 98.16 270 top
TP56  THRU HOLE  [TP_40X65]  41.91 92.79 270 top
TP57  -  [TP20_SMD]  92.26 84.7 180 bottom
TP58  -  [TP20_SMD]  95.46 83.9 180 bottom
TP59  -  [TP20_SMD]  93.86 83.9 180 bottom
TP60  -  [TP20_SMD]  96.26 83.1 180 bottom
TP61  THRU HOLE  [TP_40X65]  119.38 79.01 90 top
TP62  -  [TP20_SMD]  95.46 82.3 180 bottom
TP63  THRU HOLE  [TP_40X65]  119.38 82.82 90 top
TP64  -  [TP20_SMD]  73.42 85.33 180 bottom
TP65  -  [TP20_SMD]  94.66 75.1 180 bottom
TP66  -  [TP20_SMD]  83.13 77.17 180 bottom
TP67  -  [TP20_SMD]  74.93 73.55 180 bottom
TP68  -  [TP20_SMD]  106.96 40.58 0 top
TP69  -  [TP20_SMD]  35.05 71.26 180 bottom
TP70  -  [TP20_SMD]  125.73 30.75 0 top
TP71  -  [TP20_SMD]  95.26 68.51 180 bottom
TP72  -  [TP20_SMD]  114.68 67.83 90 bottom
TP73  -  [TP20_SMD]  78.56 67.67 180 bottom
TP74  -  [TP20_SMD]  96.22 67.59 180 bottom
TP75  -  [TP20_SMD]  110.74 63.26 180 bottom
TP76  -  [TP20_SMD]  117.19 58.66 180 bottom
TP77  -  [TP20_SMD]  115.37 59.45 180 bottom
TP78  -  [TP20_SMD]  40.64 58.31 0 bottom
TP79  -  [TP20_SMD]  121.03 54.89 180 bottom
TP80  -  [TP20_SMD]  111.89 54.89 180 bottom
TP81  THRU HOLE  [TP_40X65]  172.69 59.25 0 top
TP82  -  [TP20_SMD]  109.96 40.55 0 top
TP83  -  [TP20_SMD]  13.34 41.29 270 bottom
TP84  -  [TP20_SMD]  15.75 39.26 270 bottom
TP85  -  [TP20_SMD]  13.46 39.13 270 bottom
TP86  -  [TP20_SMD]  55.5 38.25 270 bottom
TP87  -  [TP20_SMD]  54.03 38.99 270 bottom
TP88  -  [TP20_SMD]  54.23 37.99 270 bottom
TP89  -  [TP20_SMD]  56.64 37.86 270 bottom
TP90  -  [TP20_SMD]  53.09 37.86 270 bottom
TP91  -  [TP20_SMD]  57.66 37.48 270 bottom
TP94  -  [TP20_SMD]  14.73 25.41 270 bottom
TP95  -  [TP20_SMD]  12.45 25.41 270 bottom
TP96  -  [TP20_SMD]  51.96 17.08 270 top
TP97  -  [TP20_SMD]  12.57 20.72 90 bottom
TP98  -  [TP20_SMD]  61.34 18.56 270 bottom
TP99  THRU HOLE  [TP_40X65]  22.89 11.95 90 top
TP100  -  [TP20_SMD]  11.05 12.71 90 bottom
TP101  -  [TP20_SMD]  49.96 33.17 0 top
TP102  -  [TP40_SMD]  54.89 52.66 0 top
U1  INA226AIDGSR  [MSOP10_19-68_120X120_1-1]  86.36 126.51 270 top
U2  TPS22919DCKR  [SC70-6_1-1]  81.21 125.86 180 top
U3  TCAN1042HGVD  [SOIC8_1-8]  12.7 123.08 90 top
U4  TCAN1042HGVD  [SOIC8_1-8]  22.6 123.08 90 top
U5  TPS62097RWKT  [VQFNHR11_TPS62097_80X80_1]  97.41 119.24 180 top
U6  INA226AIDGSR  [MSOP10_19-68_120X120_1-1]  150.62 121.05 90 top
U7  AT24CM01  [TSSOP8_25-59_125X180_1-2]  107.77 119.2 180 top
U8  TS3A27518ERTWR  [QFN24_19-68_160X160_0-8]  57.78 118.12 0 top
U9  TPS62097RWKT  [VQFNHR11_TPS62097_80X80_1]  32.64 116.73 90 top
U10  TXS0102DCUR  [VSSOP8_19-68_85X95_0-9]  125.98 115.84 90 top
U11  INA226AIDGSR  [MSOP10_19-68_120X120_1-1]  143.38 108.22 180 top
U12  TPS82084SILT  [USIP8_TPS82084_110X120_1-4]  156.08 105.55 90 top
U13  MT40A1G16KD-062E IT:E  [FBGA96_31-49_520X360_1-2]  90.81 104.15 0 top
U14  INA226AIDGSR  [MSOP10_19-68_120X120_1-1]  126.62 102.38 270 top
U15  DP83867IRRGZ  [QFN48_19-68_280X280_1]  39.24 101.23 0 top
U16  INA226AIDGSR  [MSOP10_19-68_120X120_1-1]  137.41 100.22 270 top
U17  TPS54334DRCT  [SON10_19-68_125X125_1]  147.83 94.38 180 top
U18  TMP100NA/3K  [SOT23-6_1-5]  72.96 94.2 90 top
U19  SN74LVC1G08DBVRE4  [SOT23-5]  28.08 89.11 0 top
U20  DP83869HMRGZT  [QFN48_19-68_280X280_1_EP4-2]  39.12 81.87 0 top
U21  CSD18543Q3A  [VSONP8_CSD18543Q_120X130_0-9]  153.6 79.01 180 top
U22  CSD18543Q3A  [VSONP8_CSD18543Q_120X130_0-9]  168.24 78.88 0 top
U23  XAM6442BSFGHAALV  [FCBGA441_31-49_680X680_2-6]  91.06 77.1 270 top
U24  CSD18543Q3A  [VSONP8_CSD18543Q_120X130_0-9]  156.13 73.97 0 top
U25  TPS62823DLCT  [VSONHR8_TPS62823_60X80_1]  134.01 75.85 180 top
U26  CSD18543Q3A  [VSONP8_CSD18543Q_120X130_0-9]  165.34 73.97 180 top
U27  TMUX154EDGSR  [MSOP10_19-68_120X120_1-1]  50.55 87.21 0 top
U28  INA226AIDGSR  [MSOP10_19-68_120X120_1-1]  138.56 69.61 270 top
U29  TMP100NA/3K  [SOT23-6_1-5]  122.43 66.18 270 top
U30  LM5140QRWGTQ1  [QFN40_19-68_240X240_0-9_EP3-4]  161.93 61.23 180 top
U31  SN74LVC1G08DBVRE4  [SOT23-5]  29.21 59.96 180 top
U32  TPS62097RWKT  [VQFNHR11_TPS62097_80X80_1]  19.43 59.83 270 top
U33  TPS74601PDRVR  [SON6_25-59_85X85_0-8]  135.76 57.04 0 top
U34  TPIC2810D  [SOIC16_1-8]  39.88 45.27 270 top
U35  SN74LVC1G11DCKR  [SC70-6]  126.75 51.7 270 top
U36  TPS2051BD  [SOIC8_1-8]  26.37 53.86 180 top
U37  SN74AVC4T245RGYR  [QFN16_19-68_160X140]  86.94 48.86 180 top
U38  TPD4S012DRYR  [SON6_SN74LVC2G17_40X60_0-6]  7.07 54.26 0 bottom
U39  TPS22918DBVR  [SOT23-6]  113.87 62.32 180 top
U40  S28HS512TGABHM010  [BGA24_39-37_240X310_1]  98.81 43.58 0 top
U41  SN74LVC1G11DCKR  [SC70-6]  140.21 42.89 90 top
U42  TPD4E004DRYR  [SON6_19-68_40X60_PB_0-6]  170.2 40.53 0 top
U43  TPS73533DRVR  [SON6_25-59_85X85]  165.74 37.61 90 top
U44  MTFC16GAPALBH-IT  [VFBGA153_19-68_460X520_1-1]  118.87 37.1 0 top
U45  TXS0102DCUR  [VSSOP8_19-68_85X95_0-9]  97.28 35.19 180 top
U46  SN74AVC2T244DQMR  [X2SON8_15-74_70X50]  90.68 34.69 90 top
U47  SN74LVC1G04DCKR  [SC70-5#2]  106.81 32.78 180 top
U48  TXS0102DCUR  [VSSOP8_19-68_85X95_0-9]  97.28 31.64 180 top
U49  TPD6E001RSER  [UQFN10_19-68_80X60_0-6]  48.13 30.62 90 top
U50  SN74LVC3G17DCUR  [VSSOP8_19-68_85X95_0-9]  124.08 27.83 180 top
U51  TCA9617BDGKR  [VSSOP8_25-59_120X120_1-1]  66.34 27.8 90 top
U52  SN74LVC1G32DBVR  [SOT23-5_1-5#2]  72.67 26.15 270 top
U53  SN74LVC1G32DBVR  [SOT23-5_1-5#2]  78.26 26.15 270 top
U54  SN74LVC1G08DBVRE4  [SOT23-5]  116.46 25.41 90 top
U55  TXS0102DCUR  [VSSOP8_19-68_85X95_0-9]  138.3 25.16 90 top
U56  SN74AVC2T244DQMR  [X2SON8_15-74_70X50]  120.5 52.19 90 top
U57  SN74LVC1G17DCKR  [SC70-5]  122 23.45 90 top
U58  TPD4E004DRYR  [SON6_19-68_40X60_PB_0-6]  170.2 23.38 0 top
U59  TM4C1294NCPDTT3R  [TQFP128_15-74_550X550_1-2]  152.95 21.73 0 top
U60  SN74CB3Q3257PWR  [TSSOP16_25-59_205X180]  102.51 11.8 0 top
U61  TPS79601DRBR  [SON8_25-59_130X130_1]  168.4 11.57 0 top
U62  TPS73525DRVR  [SON6_25-59_85X85_0-8]  90.04 128.92 90 bottom
U63  TPS22919DCKR  [SC70-6_1-1#2]  70.54 121.82 90 bottom
U64  TPS22919DCKR  [SC70-6_1-1]  38.66 119.76 90 bottom
U65  TPS62087RLTT  [VSONHR7_TPS62085_80X80_1]  144.4 119.39 180 bottom
U66  TCA9554APWR  [TSSOP16_25-59_205X180_1-2]  107.77 118.55 180 bottom
U67  SN74CB3Q3257PWR  [TSSOP16_25-59_205X180]  45.96 118.03 180 bottom
U68  TPS51206DSQR  [EDFN10_15-74_80X80_0-8]  77.34 116.22 270 bottom
U69  SN74LVC1G08DBVRE4  [SOT23-5]  45.85 109.74 90 bottom
U70  CDCLVC1310RHBR  [QFN32_19-68_200X200_1]  59.69 106.31 270 bottom
U71  25MHz  [OSC4_ASFLMB_200X130_SMD]  72.39 104.66 180 bottom
U72  TLV75518PDQNR  [X2SON4_TLV71318P_40X40_0-4]  142.49 102.76 270 bottom
U74  TPS3711DDCR  [SOT23-6_1-1]  172.37 100.08 270 bottom
U75  TS3DDR3812RUAR  [TQFN42_19-68_140X360_0-8]  52.45 96.03 180 bottom
U76  TPS3897ADRYR  [SON6_19-68_40X60_0-6]  129.03 93.64 0 bottom
U77  TLV70710DQNR  [X2SON4_TLV71318P_40X40_0-4]  46.74 93.36 0 bottom
U79  SN74AVC8T245RHL  [QFN24_19-68_220X140_1]  67.56 70.5 180 bottom
U80  DP83869HMRGZT  [QFN48_19-68_280X280_1_EP4-2]  38.99 66.25 0 bottom
U81  SN74AVC8T245RHL  [QFN24_19-68_220X140_1]  74.93 55.64 180 bottom
U82  SN74AVC4T245RSVR  [UQFN16_TMUX1574_70X100_0-6]  142.37 53.23 0 bottom
U83  93LC46B  [MSOP8_25-59_125X125_1-1]  116.46 52.59 270 bottom
U84  SN74AVC4T245RSVR  [UQFN16_TMUX1574_70X100_0-6]  135.38 51.96 0 bottom
U85  SN74LVC1G08DBVRE4  [SOT23-5]  108.08 45.35 90 bottom
U86  SN74LVC1G11DCKR  [SC70-6]  30.1 44.85 180 bottom
U87  FT4232HL  [LQFP64_19-68_390X390_1-6]  140.72 42.69 0 bottom
U88  SN74LVC1G08DBVRE4  [SOT23-5]  38.23 41.42 270 bottom
U89  SN74AVC4T245RSVR  [UQFN16_TMUX1574_70X100_0-6]  152.4 40.02 180 bottom
U90  SN74LVC1G08DBVRE4  [SOT23-5]  107.57 37.61 180 bottom
U91  TCA6424ARGJR  [QFN32_19-68_200X200]  55.24 33.16 90 bottom
U92  93LC46B  [MSOP8_25-59_125X125_1-1]  131.83 29.35 180 bottom
U93  SN74LVC1G32DBVR  [SOT23-5_1-5#2]  78.26 26.15 270 bottom
U94  SN74LVC1G32DBVR  [SOT23-5_1-5#2]  72.67 26.15 270 bottom
U95  LM4040B25IDCKR  [SC70-5_1-1]  148.21 24.87 90 bottom
U96  TCA6424ARGJR  [QFN32_19-68_200X200]  97.15 23.36 0 bottom
U97  TPS62177DQCR  [WSON10_19-68_80X120_0-8]  58.55 21.73 270 bottom
U98  SN74AVC4T245RGYR  [QFN16_19-68_160X140]  126.57 56.2 0 bottom
U99  TPS22945DCKR  [SC70-5_1-1]  24.38 19.32 270 bottom
U100  TLV70728PDQNR  [X2SON4_TLV71318P_40X40_0-4]  15.37 18.43 90 bottom
U102  SN74LVC1G32DBVR  [SOT23-5_1-5]  131.02 101.35 270 top
U103  SN74LVC1G32DBVR  [SOT23-5_1-5]  122.13 106.68 270 top
U104  SN74LVC1G08DBVRE4  [SOT23-5]  115.19 105.78 90 top
U105  CDCI6214RGET  [QFN24_19-68_160X160_1]  51.13 54.71 90 top
Y1  25.000MHz  [XTAL4_ABM10W_100X80_SMD_0-6]  100.94 56.81 0 top
Y2  16.000MHZ  [XTAL4_NX3225GA_130X100_SMD_0-9]  166.22 25.54 90 top
Y3  12.000MHz  [XTAL_ABM3_205X130_SMD_1-4]  129.79 37.23 90 bottom
Y4  25.000MHz  [XTAL_ABM3_205X130_SMD_1-4]  48.54 47.45 180 top

## Library data of the parts
C1-C55 C57-C69 C71-C99 C101 C103-C141 C144-C230 C232-C239 C241-C272 C274-C281 C283-C366 C368-C385 C387-C479 C482-C488 C491-C495 C509 C513 C517 C519-C527 C529 C532 C533 C536-C541 = CAP
C56 C70 C143 = CAP_POL
C100 C102 = CAP: signal model: CAP_CAP0201_0-5_0.22UF_0.22uF
D1 = DIODE_TVS_DUAL
D2 = DIODE
D3 = DIODE_SCHOTTKY_POWERMITE-3
D4 D5 = DIODE_SCHOTTKY
D6 D8-D11 = DIODE_SOD323
D7 = DIODE_ZENER_SOT23_13
F1 = FUSE
FB1-FB6 FB8 FB9 FB11-FB21 FB23-FB26 = INDUCTOR_FERRITE
FL7 = FILTER_NFM
FL17-FL20 = CAP_FILTER
FL22 = EMIFILTER_ACM
J1 = HEADER_12X2
J2 = CON_XMC30X5_F_SEAF
J3 = HEADER_10X2
J4 = HEADER_5X1
J5 J29 J31 J32 J34 J35 = HEADER_3X1
J6 = CON_PWRJACK2_PJ-082BH
J7 = HEADER_5X2
J8-J13 J15-J20 J22 J30 J39 J40 = HEADER_2X1
J14 = CON_RJ45-14_LPJG16314A4NL
J21 = CON_RJ45-28_LPJG17512AONL
J23 = HEADER_3X2
J24 = CON_USB_MINI-AB_10
J25 = HEADER_10X2_FTR-06
J26 J28 = CON_MUSB-B_5_1051640001
J27 = CON_MINIPCI_32X2
J33 = CON_PMC_30X2_F
J36 = CON_FLEX_14X1_FH19
J37 = CON_SDCARD_10_DM3BT-DSF-PEJS
J38 = CON_FLEX_40X1_FH12A-40S-0.5SH
L1-L9 = INDUCTOR
LD1-LD26 = DIODE_LED
Q1-Q7 Q11-Q16 Q18-Q21 = MOSFET_BSS138LT1G
Q8-Q10 Q17 = MOSFET_IRLML6401TR
R1-R21 R23-R91 R93-R145 R148 R150 R151 R153-R173 R175-R226 R228-R232 R234 R240-R271 R273-R292 R294 R297-R301 R303-R312 R314 R315 R317-R322 R324-R334 R336 R338 R340 R341 R343-R350 R352-R389 R394-R403 R405-R414 R416-R505 R507-R538 R540-R566 R574-R589 R591 R593 R594 R597-R600 R602 R604-R606 R608-R617 R622-R625 R630-R632 R634-R646 R656 R659-R662 R665 R666 R672 R679-R688 R693-R701 = RESISTOR
R22 R92 R227 R233 R295 R351 = RESISTOR-4TERM
R147 R152 R235-R239 R272 R302 R323 R404 R506 = RESISTOR: signal model: RESISTOR_RES0402_22E_22E
R390-R393 = RESISTOR: signal model: RES
R652-R655 = RESISTOR: signal model: RESISTOR_RES0402_0-5_33E_1%_33E_1%
R667 R668 = RESISTOR: signal model: RESISTOR_RES0402_0-5_0E_0E
RA1-RA6 = RESARR_ISO8_0402: signal model: RESA
SW1 = SW3_B12JV
SW2 SW3 = SW8_218-8LPSTR
SW4-SW7 = SW4_SKHUPLE010
TP1-TP91 TP94-TP102 = TESTPOINT
U1 U6 U11 U14 U16 U28 = INA226AIDGS_MSOP10
U2 U63 U64 = TPS22919_SC70-6
U3 U4 = TCAN1042HGVD_SOIC8
U5 U9 U32 = TPS62097RWKT_VQFNHR11
U7 = AT24HC04B-TH-B_TSSOP8
U8 = TS3A27518ERTWR_QFN24
U10 U45 U48 U55 = TXS0102DCUR_VSSOP8
U12 = TPS82084_USIP8
U13 = MT40A512M16LY_FBGA96
U15 = DP83867IRRGZ_VQFN48
U17 = TPS54334DRCT_VSON10
U18 U29 = TMP100NA/3K_SOT23-6
U19 U31 U54 U69 U85 U88 U90 U104 = SN74LVC1G08DBVRE4_SOT23-5
U20 U80 = DP83869HM_VQFN48
U21 U22 U24 U26 = MOSFET_CSD18501Q5A
U23 = XAM6442BSFGGAALV_BGA441
U25 = TPS62823_VSONHR8
U27 = TMUX154EDGSR_VSSOP10
U30 = LM5140QRWGTQ1_VQFNP40
U33 = TPS74501_WSON6
U34 = TPIC2810D_SOIC16
U35 U41 U86 = SN74LVC1G11DCKR_SC70-6
U36 = TPS2051BD_SOIC8
U37 U98 = SN74AVC4T245RGYR_QFN16
U38 = TPD4S012DRY_SON6
U39 = TPS22918DBVR_SOT23-6
U40 = S28HS512T_BGA24
U42 U58 = TPD4E004_SON6
U43 U62 = TPS73501DRVR_SON6
U44 = MTFC16GAPALBH_TFBGA153
U46 U56 = SN74AVC2T244DQMR_X2SON8
U47 = SN74LVC1G04DCKR_SC70-5
U49 = TPD6E001RSE_UQFN10
U50 = SN74LVC3G17DCUR_VSSOP8
U51 = TCA9617BDGKR_VSSOP8
U52 U53 U93 U94 U102 U103 = SN74LVC1G32DBVR_SOT23-5
U57 = SN74LVC1G17DCKR_SC70-5
U59 = TM4C1294NCPDTT3R_TQFP128
U60 U67 = SN74CB3Q3257PWR_TSSOP16
U61 = TPS79601DRBR_SON8
U65 = TPS62085RLTR_VSONHR7
U66 = TCA9554APWR_TSSOP16
U68 = TPS51206DSQR_WSON10
U70 = CDCLVC1310RHBR_VQFN32
U71 = OSC_ASFLMB_SMD4
U72 U77 U100 = TLV71318PDQNR_X2SON4
U74 = TPS3711DDCR_SOT23-6
U75 = TS3DDR3812RUAR_WQFN42
U76 = TPS3897ADRYR_SON6
U79 U81 = SN74AVC8T245RHL_QFN24
U82 U84 U89 = SN74AVC4T245RSV_UQFN16
U83 U92 = 93LC46B_MSOP8
U87 = FT4232H _LQFP64
U91 U96 = TCA6424ARGJR_QFN32
U95 = LM4040B25IDCKR_SC70-5
U97 = TPS62177_WSON10
U99 = TPS22945DCKR_SC70-5
U105 = CDCI6214RGET_VQFN24
Y1 = CRY4_ABM8G
Y2 = CRY4_13
Y3 Y4 = CRY

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
BGA24_39-37_240X310_1
  round 0.356 smd: A2(-1,2) A3(0,2) A4(1,2) A5(2,2) B1(-2,1) B2(-1,1) B3(0,1) B4(1,1) B5(2,1) C1(-2,0) C2(-1,0) C3(0,0) C4(1,0) C5(2,0) D1(-2,-1) D2(-1,-1) D3(0,-1) D4(1,-1) D5(2,-1) E1(-2,-2) E2(-1,-2) E3(0,-2) E4(1,-2) E5(2,-2)
CAP0201_0-5
  rect 0.356x0.33 smd: 1(-0.28,0) 2(0.28,0)
CAP0402_0-75
  rect 0.559x0.635 smd: 1(-0.49,0) 2(0.49,0)
CAP0603_1
  rect 0.94x1.016 smd: 1(-0.8,0) 2(0.8,0)
CAP0603_1#2
  rect 0.711x0.889 smd: 1(-0.7,0) 2(0.7,0)
CAP0805_1-5
  rect 0.94x1.346 smd: 1(-0.8,0) 2(0.8,0)
CAP1206_1-75
  rect 1.346x1.905 smd: 1(-1.6,0) 2(1.6,0)
CAP1206_2
  rect 1.143x1.803 smd: 1(-1.5,0) 2(1.5,0)
CAP1206_2#2
  rect 0.991x1.702 smd: 1(-1.35,0) 2(1.35,0)
CAPAE_875115252003_330X330_SMD_8-7
  rect 4.191x1.905 smd: 1(-3.5,0) 2(3.5,0)
CAPAE_D8CASE_8
  rect 3.15x1.6 smd: 1(-2.9,0) 2(2.9,0)
CAPT7343D_3-25
  rect 2.743x2.54 smd: 1(-3.2,0) 2(3.2,0)
CFP15_PMEG045V150EPD_0-9
  rect 1.448x1.6 smd: 1(-2.78,-1.065) 2(-2.78,1.065)
  rect 4.953x3.81 smd: 3(1.02,0)
CON_FLEX1X14_10051922_S_R_S
  rect 0.991x1.041 smd: (-4.475,-0.528) (4.475,-0.528)
  rect 0.356x0.838 smd: 1(-3.25,2.172) 2(-2.75,2.172) 3(-2.25,2.172) 4(-1.75,2.172) 5(-1.25,2.172) 6(-0.75,2.172) 7(-0.25,2.172) 8(0.25,2.172) 9(0.75,2.172) 10(1.25,2.172) 11(1.75,2.172) 12(2.25,2.172) 13(2.75,2.172) 14(3.25,2.172)
CON_FLEX40X1_FH12A_S_R_S
  rect 0.33x1.397 smd: 1(-9.75,3.575) 2(-9.25,3.575) 3(-8.75,3.575) 4(-8.25,3.575) 5(-7.75,3.575) 6(-7.25,3.575) 7(-6.75,3.575) 8(-6.25,3.575) 9(-5.75,3.575) 10(-5.25,3.575) 11(-4.75,3.575) 12(-4.25,3.575) 13(-3.75,3.575) 14(-3.25,3.575) 15(-2.75,3.575) 16(-2.25,3.575) 17(-1.75,3.575) 18(-1.25,3.575) 19(-0.75,3.575) 20(-0.25,3.575) 21(0.25,3.575) 22(0.75,3.575) 23(1.25,3.575) 24(1.75,3.575) 25(2.25,3.575) 26(2.75,3.575) 27(3.25,3.575) 28(3.75,3.575) 29(4.25,3.575) 30(4.75,3.575) 31(5.25,3.575) 32(5.75,3.575) 33(6.25,3.575) 34(6.75,3.575) 35(7.25,3.575) 36(7.75,3.575) 37(8.25,3.575) 38(8.75,3.575) 39(9.25,3.575) 40(9.75,3.575)
  rect 1.803x2.311 smd: 41(-11.65,0.325) 42(11.65,0.325)
CON_MINIPCI2X32_PCIE-064-02_S_S_T_11
  round 2.21 hole 2.337 unplated: (11.65,-1.24) (34.8,-1.24)
  rect 1.422x1.422 hole 0.711: A1(0,0)
  round 1.422 hole 0.711: A2(1,2) A3(2,0) A4(3,2) A5(4,0) A6(5,2) A7(6,0) A8(7,2) A9(8,0) A10(9,2) A11(10,0) A12(13,2) A13(14,0) A14(15,2) A15(16,0) A16(17,2) A17(18,0) A18(19,2) A19(20,0) A20(21,2) A21(22,0) A22(23,2) A23(24,0) A24(25,2) A25(26,0) A26(27,2) A27(28,0) A28(29,2) A29(30,0) A30(31,2) A31(32,0) A32(33,2) B1(0,-2.5) B2(1,-4.5) B3(2,-2.5) B4(3,-4.5) B5(4,-2.5) B6(5,-4.5) B7(6,-2.5) B8(7,-4.5) B9(8,-2.5) B10(9,-4.5) B11(10,-2.5) B12(13,-4.5) B13(14,-2.5) B14(15,-4.5) B15(16,-2.5) B16(17,-4.5) B17(18,-2.5) B18(19,-4.5) B19(20,-2.5) B20(21,-4.5) B21(22,-2.5) B22(23,-4.5) B23(24,-2.5) B24(25,-4.5) B25(26,-2.5) B26(27,-4.5) B27(28,-2.5) B28(29,-4.5) B29(30,-2.5) B30(31,-4.5) B31(32,-2.5) B32(33,-4.5)
CON_MUSBB5_1051640001_S_R_S_2-5
  rect 0.457x1.372 smd: 1(1.3,2.143) 2(0.65,2.143) 3(0,2.143) 4(-0.65,2.143) 5(-1.3,2.143)
  oval 1.397x2.108 hole 0.61x1.321: SH1(-3.95,-0.517) SH2(3.95,-0.517)
  rect 1.473x2.108 smd: SH3(-2.462,1.783) SH4(2.462,1.783)
  rect 1.372x1.905 smd: SH5(-0.937,-0.517) SH6(0.937,-0.517)
CON_PMC2X30_QSH-030-01-D-A_S_S_S_3-3
  round 0.889 hole 1.016 unplated: (-10.065,2.67) (10.065,2.67)
  rect 0.279x2.261 smd: 1(-7.255,-2.87) 2(-7.255,2.87) 3(-6.755,-2.87) 4(-6.755,2.87) 5(-6.255,-2.87) 6(-6.255,2.87) 7(-5.755,-2.87) 8(-5.755,2.87) 9(-5.255,-2.87) 10(-5.255,2.87) 11(-4.755,-2.87) 12(-4.755,2.87) 13(-4.255,-2.87) 14(-4.255,2.87) 15(-3.755,-2.87) 16(-3.755,2.87) 17(-3.255,-2.87) 18(-3.255,2.87) 19(-2.755,-2.87) 20(-2.755,2.87) 21(-2.255,-2.87) 22(-2.255,2.87) 23(-1.755,-2.87) 24(-1.755,2.87) 25(-1.255,-2.87) 26(-1.255,2.87) 27(-0.755,-2.87) 28(-0.755,2.87) 29(-0.255,-2.87) 30(-0.255,2.87) 31(0.245,-2.87) 32(0.245,2.87) 33(0.745,-2.87) 34(0.745,2.87) 35(1.245,-2.87) 36(1.245,2.87) 37(1.745,-2.87) 38(1.745,2.87) 39(2.245,-2.87) 40(2.245,2.87) 41(2.745,-2.87) 42(2.745,2.87) 43(3.245,-2.87) 44(3.245,2.87) 45(3.745,-2.87) 46(3.745,2.87) 47(4.245,-2.87) 48(4.245,2.87) 49(4.745,-2.87) 50(4.745,2.87) 51(5.245,-2.87) 52(5.245,2.87) 53(5.745,-2.87) 54(5.745,2.87) 55(6.245,-2.87) 56(6.245,2.87) 57(6.745,-2.87) 58(6.745,2.87) 59(7.245,-2.87) 60(7.245,2.87)
  rect 2.54x0.432 smd: 61(-8.065,0) 64(8.065,0)
  rect 4.699x0.432 smd: 62(-3.175,0) 63(3.175,0)
CON_PWRJACK2_PJ-080BH_P_R_T_13-4
  round 1.499 hole 1.626 unplated: (0,-11.65)
  rect 2.692x2.692 hole 1.981: 1(0,0)
  oval 2.794x1.549 hole 2.083x0.864: 2(0,-6.65)
  oval 1.702x2.718 hole 1.016x2.032: SH1(-5.95,-5.5) SH2(5.95,-5.5) SH3(-5.95,-10.7) SH4(5.95,-10.7)
CON_RJ45-14_LPJG16314A4NL_S_R_T_13-6
  round 3.073 hole 3.2 unplated: (0,-8.89) (11.43,-8.89)
  rect 1.6x1.6 hole 0.914: 1(0,0)
  round 1.6 hole 0.914: 2(1.27,-2.54) 3(2.54,0) 4(3.81,-2.54) 5(5.08,0) 6(6.35,-2.54) 7(7.62,0) 8(8.89,-2.54) 9(10.16,0) 10(11.43,-2.54)
  round 1.702 hole 1.016: 11(12.44,-11.43) 12(12.44,-13.462) 13(-1.01,-11.43) 14(-1.01,-13.462)
  round 2.362 hole 1.676: 15(-2.032,-5.842) 16(13.462,-5.842)
CON_RJ45-28_LPJG17512_S_R_T_25-3
  round 3.073 hole 3.2 unplated: (-2.42,-4.71) (9.01,-4.71)
  round 1.6 hole 0.914: A1(0,0) A2(1.27,1.27) A3(0,2.54) A4(1.27,3.81) A5(0,5.08) A6(1.27,6.35) A7(0,7.62) A8(1.27,8.89) A9(0,10.16) A10(1.27,11.43) A11(6.34,-3.7) A12(4.31,-3.7) A13(2.28,-3.7) A14(0.25,-3.7) B1(6.6,0) B2(5.33,1.27) B3(6.6,2.54) B4(5.33,3.81) B5(6.6,5.08) B6(5.33,6.35) B7(6.6,7.62) B8(5.33,8.89) B9(6.6,10.16) B10(5.33,11.43) B11(6.34,-1.85) B12(4.31,-1.85) B13(2.28,-1.85) B14(0.25,-1.85)
  round 2.362 hole 1.676: SH1(-5.21,10.78) SH2(11.8,6.72) SH3(-5.21,-9.28) SH4(11.8,-9.28)
CON_SD10_DM3BT-DSF-PEJS_S_R_S_2-4
  rect 0.711x1.422 smd: 1(-2.715,7.801) 2(-1.615,7.801) 3(-0.515,7.801) 4(0.585,7.801) 5(1.685,7.801) 6(2.785,7.801) 7(3.885,7.801) 8(4.985,7.801)
  rect 0.711x1.219 smd: 9(5.935,7.901)
  rect 1.016x1.422 smd: 10(-4.615,7.801)
  rect 1.219x1.219 smd: 11(6.785,3.601)
  rect 1.219x0.813 smd: 12(6.785,-2.599)
  rect 1.219x3.2 smd: 13(6.785,-6.199)
  rect 2.007x1.905 smd: 14(-6.265,-7.199)
CON_USBAB5_ZX62RD-AB-5P8_S_R_S_3-2
  rect 0.406x1.346 smd: 1(1.3,2.504) 2(0.65,2.504) 3(0,2.504) 4(-0.65,2.504) 5(-1.3,2.504)
  oval 1.067x1.727 hole 0.66x1.321: 6(2.225,2.829) 7(-2.225,2.829)
  custom 0.35x0.35 hole 0.813x1.626: 8(4.087,-0.296) 10(-4.087,-0.296)
  rect 2.896x1.905 smd: 9(0,-0.296)
CON_XMC5X30_SEAF-30-06-05-2-A_S_S_S_6-4
  round 1.143 hole 1.27 unplated: (-20.84,3.05) (20.84,0)
  round 0.635 smd: A1(-18.415,3.175) A2(-17.145,3.175) A3(-15.875,3.175) A4(-14.605,3.175) A5(-13.335,3.175) A6(-12.065,3.175) A7(-10.795,3.175) A8(-9.525,3.175) A9(-8.255,3.175) A10(-6.985,3.175) A11(-5.715,3.175) A12(-4.445,3.175) A13(-3.175,3.175) A14(-1.905,3.175) A15(-0.635,3.175) A16(0.635,3.175) A17(1.905,3.175) A18(3.175,3.175) A19(4.445,3.175) A20(5.715,3.175) A21(6.985,3.175) A22(8.255,3.175) A23(9.525,3.175) A24(10.795,3.175) A25(12.065,3.175) A26(13.335,3.175) A27(14.605,3.175) A28(15.875,3.175) A29(17.145,3.175) A30(18.415,3.175) B1(-18.415,1.905) B2(-17.145,1.905) B3(-15.875,1.905) B4(-14.605,1.905) B5(-13.335,1.905) B6(-12.065,1.905) B7(-10.795,1.905) B8(-9.525,1.905) B9(-8.255,1.905) B10(-6.985,1.905) B11(-5.715,1.905) B12(-4.445,1.905) B13(-3.175,1.905) B14(-1.905,1.905) B15(-0.635,1.905) B16(0.635,1.905) B17(1.905,1.905) B18(3.175,1.905) B19(4.445,1.905) B20(5.715,1.905) B21(6.985,1.905) B22(8.255,1.905) B23(9.525,1.905) B24(10.795,1.905) B25(12.065,1.905) B26(13.335,1.905) B27(14.605,1.905) B28(15.875,1.905) B29(17.145,1.905) B30(18.415,1.905) C1(-18.415,0.635) C2(-17.145,0.635) C3(-15.875,0.635) C4(-14.605,0.635) C5(-13.335,0.635) C6(-12.065,0.635) C7(-10.795,0.635) C8(-9.525,0.635) C9(-8.255,0.635) C10(-6.985,0.635) C11(-5.715,0.635) C12(-4.445,0.635) C13(-3.175,0.635) C14(-1.905,0.635) C15(-0.635,0.635) C16(0.635,0.635) C17(1.905,0.635) C18(3.175,0.635) C19(4.445,0.635) C20(5.715,0.635) C21(6.985,0.635) C22(8.255,0.635) C23(9.525,0.635) C24(10.795,0.635) C25(12.065,0.635) C26(13.335,0.635) C27(14.605,0.635) C28(15.875,0.635) C29(17.145,0.635) C30(18.415,0.635) D1(-18.415,-0.635) D2(-17.145,-0.635) D3(-15.875,-0.635) D4(-14.605,-0.635) D5(-13.335,-0.635) D6(-12.065,-0.635) D7(-10.795,-0.635) D8(-9.525,-0.635) D9(-8.255,-0.635) D10(-6.985,-0.635) D11(-5.715,-0.635) D12(-4.445,-0.635) D13(-3.175,-0.635) D14(-1.905,-0.635) D15(-0.635,-0.635) D16(0.635,-0.635) D17(1.905,-0.635) D18(3.175,-0.635) D19(4.445,-0.635) D20(5.715,-0.635) D21(6.985,-0.635) D22(8.255,-0.635) D23(9.525,-0.635) D24(10.795,-0.635) D25(12.065,-0.635) D26(13.335,-0.635) D27(14.605,-0.635) D28(15.875,-0.635) D29(17.145,-0.635) D30(18.415,-0.635) E1(-18.415,-1.905) E2(-17.145,-1.905) E3(-15.875,-1.905) E4(-14.605,-1.905) E5(-13.335,-1.905) E6(-12.065,-1.905) E7(-10.795,-1.905) E8(-9.525,-1.905) E9(-8.255,-1.905) E10(-6.985,-1.905) E11(-5.715,-1.905) E12(-4.445,-1.905) E13(-3.175,-1.905) E14(-1.905,-1.905) E15(-0.635,-1.905) E16(0.635,-1.905) E17(1.905,-1.905) E18(3.175,-1.905) E19(4.445,-1.905) E20(5.715,-1.905) E21(6.985,-1.905) E22(8.255,-1.905) E23(9.525,-1.905) E24(10.795,-1.905) E25(12.065,-1.905) E26(13.335,-1.905) E27(14.605,-1.905) E28(15.875,-1.905) E29(17.145,-1.905) E30(18.415,-1.905)
DIO_DFN0402_0-5
  rect 0.457x0.711 smd: 1(-0.34,0) 2(0.34,0)
DIO_SMA
  rect 1.88x1.651 smd: 1(-2.06,0) 2(2.06,0)
DIO_SMC
  rect 2.21x3.099 smd: 1(-3.5,0) 2(3.5,0)
DIO_SOD323_1
  rect 1.092x0.508 smd: 1(-1.4,0) 2(1.4,0)
EDFN10_15-74_80X80_0-8
  rect 0.787x0.203 smd: 1(-1.1,0.8) 2(-1.1,0.4) 3(-1.1,0) 4(-1.1,-0.4) 5(-1.1,-0.8) 6(1.1,-0.8) 7(1.1,-0.4) 8(1.1,0) 9(1.1,0.4) 10(1.1,0.8)
  rect 0.94x1.6 smd: 11(0,0)
EMIFIL_NFM21P_0805
  rect 0.61x0.61 smd: 1(-1,0) 3(1,0)
  rect 0.61x1.905 smd: 2(0,0)
FBGA96_31-49_520X360_1-2
  round 0.406 smd: A1(-3.2,6) A2(-2.4,6) A3(-1.6,6) A7(1.6,6) A8(2.4,6) A9(3.2,6) B1(-3.2,5.2) B2(-2.4,5.2) B3(-1.6,5.2) B7(1.6,5.2) B8(2.4,5.2) B9(3.2,5.2) C1(-3.2,4.4) C2(-2.4,4.4) C3(-1.6,4.4) C7(1.6,4.4) C8(2.4,4.4) C9(3.2,4.4) D1(-3.2,3.6) D2(-2.4,3.6) D3(-1.6,3.6) D7(1.6,3.6) D8(2.4,3.6) D9(3.2,3.6) E1(-3.2,2.8) E2(-2.4,2.8) E3(-1.6,2.8) E7(1.6,2.8) E8(2.4,2.8) E9(3.2,2.8) F1(-3.2,2) F2(-2.4,2) F3(-1.6,2) F7(1.6,2) F8(2.4,2) F9(3.2,2) G1(-3.2,1.2) G2(-2.4,1.2) G3(-1.6,1.2) G7(1.6,1.2) G8(2.4,1.2) G9(3.2,1.2) H1(-3.2,0.4) H2(-2.4,0.4) H3(-1.6,0.4) H7(1.6,0.4) H8(2.4,0.4) H9(3.2,0.4) J1(-3.2,-0.4) J2(-2.4,-0.4) J3(-1.6,-0.4) J7(1.6,-0.4) J8(2.4,-0.4) J9(3.2,-0.4) K1(-3.2,-1.2) K2(-2.4,-1.2) K3(-1.6,-1.2) K7(1.6,-1.2) K8(2.4,-1.2) K9(3.2,-1.2) L1(-3.2,-2) L2(-2.4,-2) L3(-1.6,-2) L7(1.6,-2) L8(2.4,-2) L9(3.2,-2) M1(-3.2,-2.8) M2(-2.4,-2.8) M3(-1.6,-2.8) M7(1.6,-2.8) M8(2.4,-2.8) M9(3.2,-2.8) N1(-3.2,-3.6) N2(-2.4,-3.6) N3(-1.6,-3.6) N7(1.6,-3.6) N8(2.4,-3.6) N9(3.2,-3.6) P1(-3.2,-4.4) P2(-2.4,-4.4) P3(-1.6,-4.4) P7(1.6,-4.4) P8(2.4,-4.4) P9(3.2,-4.4) R1(-3.2,-5.2) R2(-2.4,-5.2) R3(-1.6,-5.2) R7(1.6,-5.2) R8(2.4,-5.2) R9(3.2,-5.2) T1(-3.2,-6) T2(-2.4,-6) T3(-1.6,-6) T7(1.6,-6) T8(2.4,-6) T9(3.2,-6)
FCBGA441_31-49_680X680_2-6
  round 0.406 smd: A1(-8,8) A2(-7.2,8) A3(-6.4,8) A4(-5.6,8) A5(-4.8,8) A6(-4,8) A7(-3.2,8) A8(-2.4,8) A9(-1.6,8) A10(-0.8,8) A11(0,8) A12(0.8,8) A13(1.6,8) A14(2.4,8) A15(3.2,8) A16(4,8) A17(4.8,8) A18(5.6,8) A19(6.4,8) A20(7.2,8) A21(8,8) AA1(-8,-8) AA2(-7.2,-8) AA3(-6.4,-8) AA4(-5.6,-8) AA5(-4.8,-8) AA6(-4,-8) AA7(-3.2,-8) AA8(-2.4,-8) AA9(-1.6,-8) AA10(-0.8,-8) AA11(0,-8) AA12(0.8,-8) AA13(1.6,-8) AA14(2.4,-8) AA15(3.2,-8) AA16(4,-8) AA17(4.8,-8) AA18(5.6,-8) AA19(6.4,-8) AA20(7.2,-8) AA21(8,-8) B1(-8,7.2) B2(-7.2,7.2) B3(-6.4,7.2) B4(-5.6,7.2) B5(-4.8,7.2) B6(-4,7.2) B7(-3.2,7.2) B8(-2.4,7.2) B9(-1.6,7.2) B10(-0.8,7.2) B11(0,7.2) B12(0.8,7.2) B13(1.6,7.2) B14(2.4,7.2) B15(3.2,7.2) B16(4,7.2) B17(4.8,7.2) B18(5.6,7.2) B19(6.4,7.2) B20(7.2,7.2) B21(8,7.2) C1(-8,6.4) C2(-7.2,6.4) C3(-6.4,6.4) C4(-5.6,6.4) C5(-4.8,6.4) C6(-4,6.4) C7(-3.2,6.4) C8(-2.4,6.4) C9(-1.6,6.4) C10(-0.8,6.4) C11(0,6.4) C12(0.8,6.4) C13(1.6,6.4) C14(2.4,6.4) C15(3.2,6.4) C16(4,6.4) C17(4.8,6.4) C18(5.6,6.4) C19(6.4,6.4) C20(7.2,6.4) C21(8,6.4) D1(-8,5.6) D2(-7.2,5.6) D3(-6.4,5.6) D4(-5.6,5.6) D5(-4.8,5.6) D6(-4,5.6) D7(-3.2,5.6) D8(-2.4,5.6) D9(-1.6,5.6) D10(-0.8,5.6) D11(0,5.6) D12(0.8,5.6) D13(1.6,5.6) D14(2.4,5.6) D15(3.2,5.6) D16(4,5.6) D17(4.8,5.6) D18(5.6,5.6) D19(6.4,5.6) D20(7.2,5.6) D21(8,5.6) E1(-8,4.8) E2(-7.2,4.8) E3(-6.4,4.8) E4(-5.6,4.8) E5(-4.8,4.8) E6(-4,4.8) E7(-3.2,4.8) E8(-2.4,4.8) E9(-1.6,4.8) E10(-0.8,4.8) E11(0,4.8) E12(0.8,4.8) E13(1.6,4.8) E14(2.4,4.8) E15(3.2,4.8) E16(4,4.8) E17(4.8,4.8) E18(5.6,4.8) E19(6.4,4.8) E20(7.2,4.8) E21(8,4.8) F1(-8,4) F2(-7.2,4) F3(-6.4,4) F4(-5.6,4) F5(-4.8,4) F6(-4,4) F7(-3.2,4) F8(-2.4,4) F9(-1.6,4) F10(-0.8,4) F11(0,4) F12(0.8,4) F13(1.6,4) F14(2.4,4) F15(3.2,4) F16(4,4) F17(4.8,4) F18(5.6,4) F19(6.4,4) F20(7.2,4) F21(8,4) G1(-8,3.2) G2(-7.2,3.2) G3(-6.4,3.2) G4(-5.6,3.2) G5(-4.8,3.2) G6(-4,3.2) G7(-3.2,3.2) G8(-2.4,3.2) G9(-1.6,3.2) G10(-0.8,3.2) G11(0,3.2) G12(0.8,3.2) G13(1.6,3.2) G14(2.4,3.2) G15(3.2,3.2) G16(4,3.2) G17(4.8,3.2) G18(5.6,3.2) G19(6.4,3.2) G20(7.2,3.2) G21(8,3.2) H1(-8,2.4) H2(-7.2,2.4) H3(-6.4,2.4) H4(-5.6,2.4) H5(-4.8,2.4) H6(-4,2.4) H7(-3.2,2.4) H8(-2.4,2.4) H9(-1.6,2.4) H10(-0.8,2.4) H11(0,2.4) H12(0.8,2.4) H13(1.6,2.4) H14(2.4,2.4) H15(3.2,2.4) H16(4,2.4) H17(4.8,2.4) H18(5.6,2.4) H19(6.4,2.4) H20(7.2,2.4) H21(8,2.4) J1(-8,1.6) J2(-7.2,1.6) J3(-6.4,1.6) J4(-5.6,1.6) J5(-4.8,1.6) J6(-4,1.6) J7(-3.2,1.6) J8(-2.4,1.6) J9(-1.6,1.6) J10(-0.8,1.6) J11(0,1.6) J12(0.8,1.6) J13(1.6,1.6) J14(2.4,1.6) J15(3.2,1.6) J16(4,1.6) J17(4.8,1.6) J18(5.6,1.6) J19(6.4,1.6) J20(7.2,1.6) J21(8,1.6) K1(-8,0.8) K2(-7.2,0.8) K3(-6.4,0.8) K4(-5.6,0.8) K5(-4.8,0.8) K6(-4,0.8) K7(-3.2,0.8) K8(-2.4,0.8) K9(-1.6,0.8) K10(-0.8,0.8) K11(0,0.8) K12(0.8,0.8) K13(1.6,0.8) K14(2.4,0.8) K15(3.2,0.8) K16(4,0.8) K17(4.8,0.8) K18(5.6,0.8) K19(6.4,0.8) K20(7.2,0.8) K21(8,0.8) L1(-8,0) L2(-7.2,0) L3(-6.4,0) L4(-5.6,0) L5(-4.8,0) L6(-4,0) L7(-3.2,0) L8(-2.4,0) L9(-1.6,0) L10(-0.8,0) L11(0,0) L12(0.8,0) L13(1.6,0) L14(2.4,0) L15(3.2,0) L16(4,0) L17(4.8,0) L18(5.6,0) L19(6.4,0) L20(7.2,0) L21(8,0) M1(-8,-0.8) M2(-7.2,-0.8) M3(-6.4,-0.8) M4(-5.6,-0.8) M5(-4.8,-0.8) M6(-4,-0.8) M7(-3.2,-0.8) M8(-2.4,-0.8) M9(-1.6,-0.8) M10(-0.8,-0.8) M11(0,-0.8) M12(0.8,-0.8) M13(1.6,-0.8) M14(2.4,-0.8) M15(3.2,-0.8) M16(4,-0.8) M17(4.8,-0.8) M18(5.6,-0.8) M19(6.4,-0.8) M20(7.2,-0.8) M21(8,-0.8) N1(-8,-1.6) N2(-7.2,-1.6) N3(-6.4,-1.6) N4(-5.6,-1.6) N5(-4.8,-1.6) N6(-4,-1.6) N7(-3.2,-1.6) N8(-2.4,-1.6) N9(-1.6,-1.6) N10(-0.8,-1.6) N11(0,-1.6) N12(0.8,-1.6) N13(1.6,-1.6) N14(2.4,-1.6) N15(3.2,-1.6) N16(4,-1.6) N17(4.8,-1.6) N18(5.6,-1.6) N19(6.4,-1.6) N20(7.2,-1.6) N21(8,-1.6) P1(-8,-2.4) P2(-7.2,-2.4) P3(-6.4,-2.4) P4(-5.6,-2.4) P5(-4.8,-2.4) P6(-4,-2.4) P7(-3.2,-2.4) P8(-2.4,-2.4) P9(-1.6,-2.4) P10(-0.8,-2.4) P11(0,-2.4) P12(0.8,-2.4) P13(1.6,-2.4) P14(2.4,-2.4) P15(3.2,-2.4) P16(4,-2.4) P17(4.8,-2.4) P18(5.6,-2.4) P19(6.4,-2.4) P20(7.2,-2.4) P21(8,-2.4) R1(-8,-3.2) R2(-7.2,-3.2) R3(-6.4,-3.2) R4(-5.6,-3.2) R5(-4.8,-3.2) R6(-4,-3.2) R7(-3.2,-3.2) R8(-2.4,-3.2) R9(-1.6,-3.2) R10(-0.8,-3.2) R11(0,-3.2) R12(0.8,-3.2) R13(1.6,-3.2) R14(2.4,-3.2) R15(3.2,-3.2) R16(4,-3.2) R17(4.8,-3.2) R18(5.6,-3.2) R19(6.4,-3.2) R20(7.2,-3.2) R21(8,-3.2) T1(-8,-4) T2(-7.2,-4) T3(-6.4,-4) T4(-5.6,-4) T5(-4.8,-4) T6(-4,-4) T7(-3.2,-4) T8(-2.4,-4) T9(-1.6,-4) T10(-0.8,-4) T11(0,-4) T12(0.8,-4) T13(1.6,-4) T14(2.4,-4) T15(3.2,-4) T16(4,-4) T17(4.8,-4) T18(5.6,-4) T19(6.4,-4) T20(7.2,-4) T21(8,-4) U1(-8,-4.8) U2(-7.2,-4.8) U3(-6.4,-4.8) U4(-5.6,-4.8) U5(-4.8,-4.8) U6(-4,-4.8) U7(-3.2,-4.8) U8(-2.4,-4.8) U9(-1.6,-4.8) U10(-0.8,-4.8) U11(0,-4.8) U12(0.8,-4.8) U13(1.6,-4.8) U14(2.4,-4.8) U15(3.2,-4.8) U16(4,-4.8) U17(4.8,-4.8) U18(5.6,-4.8) U19(6.4,-4.8) U20(7.2,-4.8) U21(8,-4.8) V1(-8,-5.6) V2(-7.2,-5.6) V3(-6.4,-5.6) V4(-5.6,-5.6) V5(-4.8,-5.6) V6(-4,-5.6) V7(-3.2,-5.6) V8(-2.4,-5.6) V9(-1.6,-5.6) V10(-0.8,-5.6) V11(0,-5.6) V12(0.8,-5.6) V13(1.6,-5.6) V14(2.4,-5.6) V15(3.2,-5.6) V16(4,-5.6) V17(4.8,-5.6) V18(5.6,-5.6) V19(6.4,-5.6) V20(7.2,-5.6) V21(8,-5.6) W1(-8,-6.4) W2(-7.2,-6.4) W3(-6.4,-6.4) W4(-5.6,-6.4) W5(-4.8,-6.4) W6(-4,-6.4) W7(-3.2,-6.4) W8(-2.4,-6.4) W9(-1.6,-6.4) W10(-0.8,-6.4) W11(0,-6.4) W12(0.8,-6.4) W13(1.6,-6.4) W14(2.4,-6.4) W15(3.2,-6.4) W16(4,-6.4) W17(4.8,-6.4) W18(5.6,-6.4) W19(6.4,-6.4) W20(7.2,-6.4) W21(8,-6.4) Y1(-8,-7.2) Y2(-7.2,-7.2) Y3(-6.4,-7.2) Y4(-5.6,-7.2) Y5(-4.8,-7.2) Y6(-4,-7.2) Y7(-3.2,-7.2) Y8(-2.4,-7.2) Y9(-1.6,-7.2) Y10(-0.8,-7.2) Y11(0,-7.2) Y12(0.8,-7.2) Y13(1.6,-7.2) Y14(2.4,-7.2) Y15(3.2,-7.2) Y16(4,-7.2) Y17(4.8,-7.2) Y18(5.6,-7.2) Y19(6.4,-7.2) Y20(7.2,-7.2) Y21(8,-7.2)
