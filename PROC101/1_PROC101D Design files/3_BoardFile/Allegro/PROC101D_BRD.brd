# Allegro board PROC101D_BRD.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VCC1V1_PG: length 12.1
  TOP w0.254: U32.5 18.01,59.58 17.88,59.45 v1(17.27,59.45) ; R136.2 v1(10.71,60.84)
  BOTTOM w0.254: v1(10.71,60.84) 15.89,60.84 v1(17.27,59.45) 17.27,58.56 17.53,58.31 R396.1
VCC1V2_DDR: length 3.1
  TOP w0.254: C20.1 99.43,120.15 U5.3
  BOTTOM w0.254: R214.1 100.22,122.06 v1(100.46,122.3)
  vias: v1(90.93,119) v1(90.93,117.98) v1(91.95,119) v1(91.95,117.98) v1(100.46,123.32) v1(100.46,121.28) v1(101.47,123.32) v1(101.47,122.3) v1(101.47,121.28)
VCC1V2_PG: length 130.8
  TOP w0.147: R14.2 125.11,121.39 124.96,121.54 v1(124.21,121.54) 124.21,120.28 123.34,119.42 123.34,118.52 124.27,117.6 124.27,109.41 123.08,108.23 U103.1 123.08,107.16 122.9,106.99 117.75,106.99 116.69,105.93 114.86,105.93 114.24,105.31 U104.1
  TOP w0.254: U5.5 97.16,120.66 97.03,120.79 97.03,121.16 v1(96.52,121.67)
  TOP w0.381: v1(136.09,71.7) 136.09,72.55 R697.2
  L03_SIG1 w0.091: v1(124.21,121.54) 120.47,121.54 115.36,126.66 102.38,126.66 97.39,121.67 v1(96.52,121.67)
  BOTTOM w0.147: v1(124.21,121.54) 121.08,121.54 119.39,119.85 119.39,91.11 123.03,87.48 123.03,77.05 124.36,75.72 131.98,75.72 133.32,74.37 133.32,73.46 135.08,71.7 v1(136.09,71.7)
  BOTTOM w0.254: v1(96.52,121.67) 96,121.14 R219.1
VCC1V8: length 101.5
  TOP w0.203: v1(117.62,33.26) U44.P5 U44.N4 ; U44.N4 U44.P3 116.62,33.5 v1(116.41,33.29) ; U44.N4 U44.M4 ; U44.C6 118.12,39.1 v1(118.37,38.85)
  TOP w0.254: R169.1 104.45,44.46 104.71,44.21 v1(104.71,43.07) ; v1(127.13,112.41) C30.2 126.47,112.94 126.23,113.18 U10.3 ; v1(104.71,43.07) R172.1 ; v1(104.71,43.07) 104.71,41.92 104.45,41.67 R173.1 ; R168.2 v1(92.65,44.59) ; U40.B4 v1(100.31,45.08) ; U40.E4 101.62,39.77 101.62,38.45 C477.1 101.62,38.39 v1(101.62,36.91) ; U40.D1 95.65,42.58 95.12,42.05 94.4,42.05 C476.1 94.37,42.05 92.91,42.05 92.65,41.79 v1(92.65,41.42) 92.65,41.04 92.91,40.78 R176.1 ; R156.2 v1(102.3,47.26) ; R24.2 v1(128.27,119.14) ; R155.1 v1(96.7,47.96)
  TOP w0.381: R193.1 v1(118.35,29.5) ; v1(115.46,29.59) C170.1 115.46,28.01 115.51,27.96 U54.5 ; FB25.1 62.31,110.36 v1(62.53,110.13) ; v1(126.12,48.88) C485.2 U35.5 ; R575.1 v1(124.57,48.9)
  L05_PWR1 w0.254: v1(68.81,99.8) 67.69,98.68 67.69,92.25 66.4,90.96 63.78,90.96 54.99,82.17 54.99,70.97 48.13,64.11 v1(48.13,61.78)
  BOTTOM w0.254: C430.1 118.5,38.98 v1(118.37,38.85) ; C443.1 117.75,33.14 v1(117.62,33.26) ; R414.2 v1(105.16,48.66) ; R429.2 111.12,42.05 v1(111.51,42.43) ; U65.4 145.81,118.64 v1(146.05,118.89) 145.79,119.14 U65.3 ; U63.1 71.19,121.53 70.94,121.77 70.07,121.77 69.89,121.59 U63.3 ; R457.1 116.15,33.55 v1(116.41,33.29) ; R456.1 119.28,33.64 v1(119.63,33.29) ; C415.1 C418.1 100.29,45.57 100.31,45.55 v1(100.31,45.08)
  BOTTOM w0.381: v1(111,47.64) 110.87,47.51 C417.1 U85.5 ; U63.1 71.19,120.13 71.61,119.7 C212.1 v1(71.61,117.97)
  vias: v1(48.23,60.97) v1(55.73,62.97) v1(55.83,62.16) v1(114.55,46.54) v1(116.84,46.54) v1(121.41,46.54) v1(134.62,110.89) v1(134.62,109.87) v1(134.62,108.85) v1(135.64,110.89) v1(135.64,109.87) v1(135.64,108.85) v1(136.65,110.89) v1(136.65,109.87) v1(136.65,108.85)
VCC1V8_HSE: length 1.8
  TOP w0.254: J2.C3 v1(72.01,129.81) ; J2.C2 v1(73.28,129.81)
  vias: v1(71.37,124.6) v1(71.37,123.59) v1(72.39,124.6) v1(72.39,123.59) v1(73.41,124.6) v1(73.41,123.59)
VCC2V5_PG: length 8.8
  TOP w0.254: v1(34.8,117.11) 34.19,117.11 34.06,116.98 U9.5
  BOTTOM w0.254: R217.2 33.4,120.92 34.27,120.05 R225.1 34.27,118.24 34.8,117.71 v1(34.8,117.11)
VCC3V3_IO_HSE: length 9.3
  TOP w0.305: 38.71,125.87 38.71,126.28 J2.A29 38.33,126.63 38.02,126.33 38.02,125.87 38,125.85 ; 40.49,125.87 40.49,126.25 40.87,126.63 J2.A27 41.4,126.13 41.4,125.92 ; 39.24,125.87 39.24,126.25 J2.A28 39.98,126.28 39.98,125.9 39.95,125.87
  BOTTOM w0.381: U64.6 39.31,121.93 39.02,122.21 ; 39.02,122.21 39.02,122.56 v1(39.61,122.56) ; 39.02,122.21 38.66,121.85 U64.5
  vias: v1(39.61,124.59) v1(39.61,123.57) v1(40.62,124.59) v1(40.62,123.57) v1(40.62,122.56)
VCC3V3_PREREG: length 113.8
  TOP w0.254: v1(122.76,30.91) 122.13,30.91 120.14,28.93 120.14,28.55 120.05,28.46 120.05,27.5 120.04,27.48 120.04,26.68 120.14,26.58 120.14,26.22 120.15,26.21 C179.2 120.8,24.54 120.81,24.55 U57.5 ; 131.85,75.3 132.14,75.6 U25.7 ; 96.61,116.06 96.61,116.9 96.52,116.99 96.52,117.7 96.66,117.84 U5.8 ; U5.7 96.3,119.01 96.01,118.73 ; R58.2 156.48,101.89 156.72,102.12 156.72,102.38 v1(157.48,103.14)
  TOP w0.381: U104.5 C479.1 v1(114.24,110.12) ; v1(123.08,102.73) C495.2 U103.5 ; 159.46,103.39 159.46,103.65
  L06_PWR2 w0.508: v1(131.06,91.96) 131.06,96.93 128.5,99.49 126.31,99.49 v1(123.08,102.73) 123.08,103.75 116.31,110.52 114.64,110.52 v1(114.24,110.12)
  BOTTOM w0.254: U72.4 142.17,100.58 142.24,100.51 ; U76.6 130.54,93.14 C283.2 ; R276.1 153.65,99.06 v1(154.56,99.96) ; v1(94.74,118.11) 93.94,118.11 93.36,118.69 R219.2
  BOTTOM w0.381: C283.2 131.08,91.98 v1(131.06,91.96) ; v1(122.76,30.91) 122.76,32.33 125.37,34.95 125.37,45.47 130,50.09 130,55.17 131.74,56.91 136.91,56.91 v1(137.92,57.93) ; R277.1 156.08,99.46 v1(155.57,99.96) ; v1(159.38,103.14) 160.87,104.63 171.93,104.63 172.45,104.1 R259.1
  vias: v1(94.87,116.7) v1(95.63,115.68) v1(95.89,117.71) v1(131.47,73.82) v1(131.47,72.8) v1(131.47,71.79) v1(132.48,73.82) v1(132.48,72.8) v1(132.48,71.79) v1(133.63,71.79) v1(138.68,59.58) v1(138.68,58.56) v1(140.59,100.85) v1(141.35,101.49) v1(141.35,100.34) v1(141.48,122.19) v1(141.48,121.3) v1(142.49,122.19) v1(142.49,121.3) v1(143.51,122.19) v1(143.51,121.3) v1(154.56,100.98) v1(155.57,100.98) v1(156.59,100.98) v1(156.59,99.96) v1(157.61,100.98) v1(157.61,99.96) v1(157.99,104.15) v1(158.5,103.14)
VCC3V3_PREREG_EN: length 13
  TOP w0.147: U102.4 130.07,99.23 133.49,95.81 138.29,95.81 139.2,96.71 R579.2
VCC3V3_R: length 3.4
  BOTTOM w0.203: R411.1 62.36,48.88 62.72,48.51 J33.1
VCC3V3_REF: length 6
  TOP w0.305: U105.3 50.88,52.1
  TOP w0.381: 50.88,52.1 50.88,51.45 C524.1 C521.1 C509.1 55.52,51.12 FL19.3
VCC3V3_SYS_PG: length 255.2
  TOP w0.147: v1(124.59,33.27) 124.59,42.42 135.64,53.47 138.94,53.47 139.94,54.46 R583.2 139.94,55.43 140.64,56.13 144.14,56.13 148.55,60.54 148.55,61.93 v1(150,63.38) R131.2 150.94,63.48 C118.1 152.22,63.68 155.55,63.68 155.9,63.32 155.9,62.18 156.4,61.69 156.71,61.69 157,61.98 U30.24
  L03_SIG1 w0.091: v1(150,63.38) 150.72,64.1 150.72,88.76 151.44,89.48 151.44,101.04 154.89,104.48 154.89,119.94 153.4,121.43 v1(147.45,121.43) ; v1(12.97,19.41) 14.73,17.65 57.4,17.65 60.83,14.22 90.55,14.22 94.61,10.16 98.17,10.16 98.68,10.67 103.12,10.67 108.46,16 113.16,16 118.87,21.72 118.87,27.84 122.48,31.45 123.47,31.45 124.59,32.56 v1(124.59,33.27)
  BOTTOM w0.254: TP97.1 12.57,19.81 v1(12.97,19.41) R589.2 ; TP49.1 R580.2 146.72,121.43 v1(147.45,121.43)
VCC3V3_TA: length 118.2
  TOP w0.254: U51.1 65.37,23.74 C181.1 v1(65.85,22.48) ; v1(95.9,19.86) 95.9,20.09 C190.2 ; R185.2 v1(68.3,33.29)
  TOP w0.381: TP96.1 51.82,16.94 v1(51.82,15.64) 53.89,15.64 R201.1 ; U102.5 133.33,100.05 C494.2 134.15,99.94 134.57,100.36 v1(138.27,100.36)
  L05_PWR1 w0.381: v1(71.88,69.22) 71.48,68.81 71.48,67.98 71.75,67.71 v1(71.75,65.67)
  L06_PWR2 w0.381: v1(138.27,100.36) 138.63,100.36 139.66,99.32 139.66,98.1 145.54,92.22 146.7,92.22 147.49,91.43 147.49,75.2 136.75,64.45 134.01,64.45 133.03,63.47 133.03,63.41 132.7,63.07 132.63,63.07 126.1,56.54 125.94,56.54 125.79,56.39 125.24,56.39 119.02,50.17 109.65,50.17
  BOTTOM w0.254: v1(94.34,20.16) 94.34,19.65 93.99,19.3 R533.2 ; U96.27 v1(97.9,19.86) ; U96.31 v1(95.9,19.86) ; R495.1 65.68,24.88 v1(66.37,24.2) 67.01,24.83 R494.1 ; v1(71.88,69.22) 71.88,69.76 C388.1 71.43,69.75 U79.1 ; v1(79.99,54.99) C405.1 78.6,54.99 78.5,54.89 U81.1 ; R355.2 71.63,65.8 v1(71.75,65.67) ; R535.2 v1(59.44,16.91)
  BOTTOM w0.305: v1(58.67,19.57) 58.67,19.7 58.55,19.83 U97.8 ; J38.3 82.41,15.18 82.55,15.32 ; 56.52,20.33 56.81,20.63 U97.10
  BOTTOM w0.381: U90.5 105.06,38.56 104.98,38.48 C434.1 v1(104.27,39.26) ; R550.1 v1(64.88,17.27) R551.1 ; R439.1 v1(111.91,38.6)
  vias: v1(50.8,15.64) v1(50.8,14.62) v1(51.82,14.62) v1(68.05,20.64) v1(70.33,20.64) v1(72.62,20.64) v1(83.24,17.61) v1(83.24,16.59) v1(84.25,17.61) v1(84.25,16.59)
VCC3V3_VCO: length 6.6
  TOP w0.305: U105.24 49.08,53.14
  TOP w0.381: FL20.3 43.37,52.43 44.11,52.43 44.38,52.16 C513.1 C520.1 C527.1 47.61,52.22 48.16,52.22 49.08,53.14
VCC3V3_XDS: length 53.3
  TOP w0.203: v1(153.01,32.01) C167.1 153.01,30.72 152.75,30.46 U59.113 ; 144.02,25.85 144.34,25.53 U59.7 ; C192.2 143.83,17.13 U59.28 ; U59.26 v1(144.02,17.93) ; U59.52 154.35,12.89 v1(154.18,12.71) 153.95,12.94 U59.51 ; 152.35,13.05 U59.47 ; v1(161.93,17.29) 161.77,17.13 U59.69 ; C176.1 143,25.13 U59.8 ; U59.90 161.66,25.53 161.67,25.54 ; U59.122 149.15,31.11 C166.1 ; U56.8 118.97,52.79 ; U59.79 161.55,21.13 161.82,20.86 ; U59.101 v1(157.55,28.27) ; U59.39 v1(149.15,15.25) ; U59.16 v1(143.95,21.93)
  TOP w0.254: C198.1 163.94,8.76 v1(163.97,8.73) ; C192.2 v1(142.83,16.95) ; 118.97,52.79 118.94,52.75 ; 152.18,12.88 152.35,13.05
  TOP w0.305: 138.05,26.81 138.05,27.89
  TOP w0.381: 144.02,25.85 143.57,26.3 C174.1 v1(142.9,26.92) ; R202.1 v1(149.52,10.47) ; v1(148.34,31.13) C166.1 ; 161.82,20.86 162.07,20.61 C191.1 v1(162.43,20.08) ; 161.67,25.54 161.82,25.69 C175.1 162.83,25.69 v1(163,25.86) ; 138.05,27.89 137.94,28.01 C171.2 v1(137.16,28.72) ; R199.2 v1(164.46,17.79) ; 152.18,12.88 C196.2 v1(152.18,11.7) ; v1(118.29,53.53) C178.2 118.94,52.75 ; R203.1 v1(150.79,10.47) ; v1(142.9,25.67) C176.1 ; R200.2 v1(165.48,16.52)
  BOTTOM w0.254: R557.2 R558.2 ; v1(123.14,52.45) 122.63,52.45 122.59,52.49 119.33,52.49 v1(118.29,53.53) ; C464.2 122.91,54.53 123.83,55.45 U98.16 ; R560.2 R559.2
  BOTTOM w0.381: R505.1 v1(141.35,22.49) ; v1(123.14,52.45) 123.11,52.48 123.11,53.04 C464.2 ; R558.2 v1(159.05,9.12) ; R560.2 v1(156.51,9.12)
  vias: v1(163.83,11.7) v1(164.72,11.44)
VCC5V0_PG: length 82.6
  TOP w0.147: v1(168.9,62.11) R134.1 167.78,62.11 167.65,61.98 U30.7 ; U102.1 v1(131.97,103.93)
  L08_SIG2 w0.091: v1(168.9,62.11) 170.56,63.77 170.56,72.26 172.21,73.91 172.21,84.33 169.04,87.5 152.29,87.5 144.31,95.48 144.31,102.9 142.01,105.2 133.24,105.2 v1(131.97,103.93)
VCC_1V8_FT4232: length 11.2
  BOTTOM w0.254: v1(133.08,45.72) C420.2 133.61,44.44 U87.12 ; v1(148.84,44.46) 148.1,44.46 C419.2 148.04,44.44 U87.37 ; U87.49 144.47,35.08 C441.1 145.14,35.05 v1(145.4,35.3) ; U87.64 136.97,35.81 136.71,35.56 C440.2
  BOTTOM w0.381: C440.2 v1(135.4,35.56)
VCC_3V3_FT4232: length 46.4
  TOP w0.381: v1(164.83,34.29) C158.1 165.09,35.32 U43.1 ; R191.2 v1(131.72,28.32)
  TOP w0.508: v1(133.6,31.26) 133.62,31.24 R186.2 ; LD21.2 137.96,32.56 v1(138.3,32.91)
  BOTTOM w0.203: 133.38,51.42 133.73,51.76 U84.2 ; U82.2 140.97,53.03 140.34,52.4 C409.2 ; U89.2 153.74,40.22 153.92,40.4 153.92,40.78 154.2,41.05 C424.2
  BOTTOM w0.254: U87.50 143.97,35.93 143.51,35.48 v1(143.51,34.69) ; U87.20 138.47,49.73 C412.2 v1(139.43,49.94) ; C424.2 v1(155.43,41.05) ; v1(143.26,50.18) 143.38,50.05 C413.2 143.97,50 U87.31 ; U87.42 147.61,41.94 147.62,41.92 C423.2 148.23,42.67 v1(148.21,42.69) ; U87.56 140.97,35.31 C442.2 v1(139.97,35.3) ; C409.2 v1(139.46,51.81) ; FB24.2 v1(129.67,41.16) ; FB23.2 v1(129.67,42.94)
  BOTTOM w0.381: U92.8 128.28,30.33 128.09,30.51 C445.2 v1(126.64,30.51) ; v1(155.43,41.05) 155.89,40.59 159.13,40.59 164.83,34.89 v1(164.83,34.29) ; 133.38,51.42 133.22,51.25 C414.2 132.35,49.4 v1(132.33,49.42)
  BOTTOM w0.508: v1(133.6,31.26) 133.35,31.26 133.11,31.49 R463.2
VCC_3V3_MIPI: length 83.9
  TOP w0.254: v1(101.72,32.13) C164.2 100.18,32.13 99.95,31.89 98.94,31.89 U48.3
  L03_SIG1 w0.254: 99.08,34.19 99.08,34.29 98.3,35.07 96.98,35.07 96.73,35.32 95.25,35.32 v1(93.71,33.78) ; 99.08,34.19 v1(98.61,33.72) ; 99.08,34.19 100.31,34.19 101.72,32.79 v1(101.72,32.13) 98.82,29.22 81.03,29.22 78.99,27.19 72.15,27.19 69.47,29.87 69.47,34.25 v1(68.07,35.64)
  L08_SIG2 w0.381: v1(68.07,35.64) 65.52,38.2 65.52,40.51 66.29,41.29 66.29,51.2 64.68,52.81 v1(61.47,52.81)
  BOTTOM w0.147: R447.1 v1(68.07,35.64)
  BOTTOM w0.305: R461.1 R460.1 v1(98.61,33.72)
  BOTTOM w0.381: R459.2 v1(93.71,33.78) ; v1(61.47,52.81) v1(60.16,52.81) 59.18,52.81
VCC_3V3_SYS: length 403.3
  TOP w0.152: FB26.1 v1(12.01,110.87)
  TOP w0.203: C155.2 89.84,37.08 89.84,36.95 ; U46.1 90.08,33.45 ; U44.J10 v1(119.62,36.35) U44.K9 ; 119.9,50.7 U56.1 ; 90.08,35.92 U46.8
  TOP w0.254: R19.2 73.71,120.12 74.22,119.61 74.59,119.61 v1(75.06,119.14) ; J1.1 141.73,127.48 141.86,127.36 C5.2 C6.1 v1(144.04,126.36) ; v1(44.58,89.55) 44.7,89.42 R101.1 ; v1(39.27,88.03) 39.24,88.03 39.16,87.95 R104.1 ; R197.2 99.97,18.4 v1(99.95,18.38) ; C35.1 40.17,105.85 39.99,105.67 U15.41 ; R143.2 139.94,57.91 v1(139.95,57.93) ; R18.1 114.63,120.71 114.88,120.46 v1(114.88,119.82) ; U20.30 43.98,81.62 44.32,81.28 44.32,80.36 C83.1 44.94,79.75 v1(44.94,79.04) ; R79.2 38.04,95.35 37.85,95.16 R81.1 v1(36.47,95.16) ; v1(90.32,50.54) C145.2 90.25,49.61 U37.1 ; v1(74.42,22.72) C182.2 U52.5 ; U32.8 20.83,59.08 20.97,58.94 21.68,58.94 21.77,59.03 22.61,59.03 ; R113.1 144.89,76.09 144.5,76.48 144.5,78.41 ; 29.46,117.53 30.3,117.53 30.39,117.62 30.97,117.62 31.1,117.48 U9.8 ; U1.1 v1(87.36,129.92) ; U44.F5 v1(118.12,37.85) U44.E6 ; v1(40.01,88.66) 40.04,88.62 R103.2 ; v1(30.84,95.85) 30.82,95.86 R76.1 ; R105.2 v1(37.47,88.61) ; U20.18 C90.1 39.41,76.87 v1(39.59,77.05) ; C155.2 v1(89.99,37.98) ; v1(80.01,22.72) C183.2 U53.5 ; R42.2 v1(37.59,108.12) ; R153.1 20.4,55.77 v1(20.27,55.89) ; v1(92.85,31.15) C163.2 94.38,31.15 94.62,31.39 U48.7 ; R41.1 42.46,107.42 42.55,107.33 v1(42.59,107.33) 43.53,107.33 R39.2 ; R188.2 v1(76.16,30.46) ; v1(53.49,117.22) C26.1 54.51,117.37 U8.5 ; v1(108.56,14.08) C194.2 U60.16 ; R128.1 R126.1 v1(45.71,64.67) ; 119.9,50.7 119.58,50.38 C189.2 ; 89.84,36.95 89.84,36.16 90.08,35.92 ; R15.2 v1(122.92,119.79) ; U6.6 151.62,124.22 C10.1 152.76,124.62 v1(152.78,124.6) ; U27.10 52.75,89.05 52.69,89.11 C89.1 52.69,90.21 v1(52.55,90.35) ; U10.7 125.73,118.34 125.58,118.49 C22.2 v1(125.58,119.89) ; R187.2 v1(70.58,30.46) ; v1(64.98,33.3) C161.1 64.98,31.71 65.37,31.32 U51.8 ; R37.2 v1(29.46,108.6) ; R95.1 v1(38.48,91.16) ; v1(40.89,96.28) 40.82,96.21 C52.1 40.14,96.53 39.49,97.17 U15.19 ; R98.1 v1(75.69,89.68) ; v1(31.46,90.91) C67.1 30.81,90.09 30.78,90.06 U19.5 ; R210.2 v1(97.31,10.92) ; v1(150.79,61.87) 150.84,61.91 R131.1 ; v1(39.46,71.06) 39.28,71.24 C101.1 ; v1(65.02,49.42) 65.15,49.54 R150.1 ; C55.2 141.6,91.96 ; v1(90.32,47.28) C146.2 90.28,48.11 U37.16 ; v1(135.45,69.28) 136.14,68.59 C109.1 137.05,67.43 137.07,67.41 U28.6 ; U9.7 32.41,117.84 32.13,118.12 ; U45.3 99.82,35.44 100.06,35.68 C157.2 v1(101.71,35.68) ; v1(39.88,72.93) 39.88,73.17 39.94,73.23 C99.1 v1(40.6,73.67) ; v1(73.79,49.31) C144.2 J25.5 ; U32.7 19.66,58.72 19.94,58.43 ; v1(44.82,69.07) 44.76,69.01 C104.1 ; R94.1 v1(35.43,91.16) ; v1(92.85,34.7) C156.2 94.38,34.7 94.61,34.94 95.63,34.94 U45.7 ; R51.1 v1(48.72,104.08) ; v1(89.99,31.52) C162.2 89.84,32.42 89.84,33.21 90.08,33.45 ; R7.2 v1(170.69,125.87) ; v1(45.92,102.81) 45.89,102.85 R56.1 ; U47.5 C165.2 v1(102.86,32.13) ; v1(41.27,75.52) R114.1 ; U6.2 v1(150.12,119.9) ; v1(35.94,110.63) R32.1 R33.1 ; J7.10 7.28,112.41 7.39,112.3 C29.1 v1(8.51,111.52) ; U15.30 43.32,100.98 43.32,100.99 43.74,100.99 43.75,100.98 43.88,100.98 44.05,100.81 44.09,100.81 44.5,100.41 44.5,100.15 44.5,100.15 44.5,99.68 45.02,99.17 C44.1 45.02,98.97 45.07,98.91 v1(45.07,98.41) ; R6.2 v1(166.24,124.47) ; R35.1 v1(41.02,110) ; R184.2 v1(111.25,34.3)
  TOP w0.279: 121.55,27.08 U50.8
  TOP w0.305: C35.1 40.75,106.46 40.76,106.44 v1(40.79,106.44) ; U14.6 125.62,99.34 125.22,98.95 C45.1 ; R47.2 v1(135.15,104.17) ; U16.6 136.41,97.17 136.03,96.79 C50.1 ; 138.81,22.53 138.55,22.78 U55.3 ; U1.6 85.36,123.35 84.94,122.93 C17.1 ; C32.1 139.95,109.49 140.22,109.22 U11.6 ; R686.1 v1(43.21,56.01) ; R672.1 55.73,56.22 56.36,56.85 v1(56.36,58.7)
  TOP w0.381: C189.2 118.56,49.47 v1(118.26,49.17) ; R133.1 v1(123.68,62.01) ; v1(120.65,26.43) C173.2 121.55,27.08 121.55,27.08 ; R574.1 129.58,54.31 130.15,54.31 v1(130.58,54.74) ; v1(46.1,49.33) 44.7,49.33 44.32,48.95 U34.1 ; R613.2 v1(12.95,87.96) ; v1(42.57,50.39) FL20.1 v1(43.33,49.61) ; C50.1 135.24,97.66 v1(135.25,97.68) ; v1(103.19,116.39) C27.2 104.74,117.1 104.77,117.13 U7.8 ; v1(18.76,123.17) 18.72,123.2 FB1.1 17.87,122.35 v1(17.83,122.32) ; R125.1 v1(122.17,70.35) ; R641.1 62.95,37.21 62.27,37.89 62.27,38.59 v1(61.65,39.22) ; v1(56.87,48.74) 56.49,49.12 FL19.1 v1(54.81,49.12) ; R642.1 60.67,51.28 v1(59.18,49.8) ; v1(75.82,96.53) C53.2 U18.4 ; R72.1 v1(74.8,97.55) ; v1(139.45,45.94) C151.2 140.23,45.23 140.21,45.21 U41.5 ; R612.2 v1(5.53,87.21) ; C45.1 124.44,99.82 v1(124.46,99.84) ; R635.1 v1(166.4,42.95) ; U29.4 120.37,64.78 120.35,64.8 C113.2 118.6,64.8 v1(118.29,65.12) ; R25.1 102.29,117.81 v1(101.56,117.81) ; C17.1 83.93,122.93 v1(83.19,122.19) ; R196.2 v1(116.44,21.37) ; 138.81,22.53 139.06,22.27 139.06,21.62 C188.2 v1(139.05,20.99) ; R27.1 v1(114.24,116.52) ; R634.1 v1(162.08,43.66) ; v1(140.84,110.38) 140.82,110.4 C32.1 ; U31.5 26.67,59.01 26.62,58.96 C128.1 v1(25.91,58.31) ; R564.1 v1(32.89,91.63)
  BOTTOM w0.203: U84.3 133.3,52.16 133.1,51.96 132.7,51.96 C408.2 ; 76.2,114.06 76.54,114.4 U68.10 ; U82.3 140.51,53.43 ; U89.3 154.52,39.82 C429.2 ; U68.2 76.94,118.61 76.96,118.63
  BOTTOM w0.254: C209.1 101.9,120.82 100.97,119.89 100.97,118.4 v1(101.56,117.81) ; C207.2 42.81,121.06 42.96,120.9 U67.16 ; R455.1 93.41,34.76 93.35,34.7 v1(92.85,34.7) ; 15.62,20.68 15.69,20.61 U100.4 ; v1(27.05,45.73) C421.1 27.7,44.83 27.72,44.85 U86.5 ; U98.1 123.82,56.95 123.79,56.98 C461.2 v1(122.36,56.98) ; C90.1 39.41,76.87 v1(39.59,77.05) ; R424.1 v1(33.91,43.19) ; R416.2 v1(34.8,45.48) ; C438.1 119.79,36.18 v1(119.62,36.35) ; v1(76.51,22.72) C456.2 U93.5 ; U99.5 23.73,16.95 23.77,16.92 C470.2 v1(22.86,16.27) ; R388.1 v1(35.31,56.96) ; v1(137.79,54.62) R403.2 138.7,55.92 138.68,55.94 138.68,57.29 139.32,57.93 v1(139.95,57.93) ; R357.1 R353.1 v1(125.77,67.54) ; R562.1 v1(32.74,56.99) ; R242.2 v1(48.51,110.12) ; R225.2 32,118.89 v1(31.62,118.51) ; v1(79.99,56.42) C404.1 78.6,56.42 78.57,56.39 U81.24 ; R637.2 v1(84.41,27.02) ; R640.1 85.16,44.3 84.96,44.1 v1(84.96,43.21) ; v1(39.46,71.06) 39.28,71.24 C101.1 U80.18 ; v1(114.81,58.05) 114.9,57.96 R395.2 ; U79.24 C384.1 71.66,71.66 v1(72.01,72.01) ; v1(40.89,96.28) 40.88,96.27 40.2,96.27 C52.1 ; R516.1 v1(26.8,22.24) ; R482.2 v1(24.37,25.94) ; v1(99.81,33.69) 99.81,34.41 R458.1 ; C436.1 C435.1 v1(20.85,37.5) ; U75.1 C260.1 55.77,100.71 v1(55.75,100.73) ; v1(39.14,60.09) 39.12,60.09 39.03,60.17 R369.1 ; R517.2 R527.2 ; R517.2 R512.2 R508.2 R501.2 R496.2 R487.2 R472.2 92.07,30.89 92.34,31.15 v1(92.85,31.15) ; R517.2 v1(84.46,31.49) ; R211.2 v1(160.53,126) ; v1(44.82,69.07) 44.82,68.37 C389.1 44.21,67.76 44.21,67.18 43.52,66.5 U80.30 ; R212.2 v1(31.01,123.6) ; v1(114.88,119.82) 114.73,119.68 R224.2 ; R336.1 v1(4.19,74.85) ; R362.1 v1(171.21,62.52) ; R358.1 R354.1 111.61,66.69 v1(111.86,66.94) ; v1(134.4,55.54) 134.49,55.46 R608.1 ; U91.31 58.82,31.91 58.84,31.89 C444.2 v1(59.45,31.15) ; U77.4 47.57,93.03 v1(47.88,92.72) ; R285.1 128.92,96.14 v1(128.78,96.28) ; R265.1 v1(133.35,102.25) ; R366.1 45.32,62.11 v1(45.6,62.11) ; v1(20.65,42.13) 20.14,42.13 19.98,42.29 R431.1 ; v1(26.9,75.82) 26.9,76.61 26.81,76.69 FB14.1 ; R438.2 v1(156.34,38.11) ; R370.2 40.47,60.04 40.51,60.09 v1(40.54,60.09) ; R278.1 v1(57.52,96.27) ; R394.2 v1(118.02,58.04) ; v1(47.5,83.45) R310.1 R308.1 ; R465.2 v1(60.43,29.75) ; U81.23 v1(77.67,57.37) ; U75.30 49.68,96.03 C276.1 v1(48.41,95.75) ; 34.09,73.51 34.15,73.51 34.18,73.54 ; R387.1 v1(38.35,56.96) ; v1(70.41,71.98) 70.17,72.22 U79.23 ; R305.2 137.26,86.28 137.29,86.25 v1(137.79,86.25) ; R360.2 141.12,64.26 141.75,63.62 141.78,63.62 v1(142.14,63.26) ; R609.1 150.72,35.56 150.42,35.26 v1(150.42,35.18) ; U94.5 C457.2 v1(70.92,22.72) ; U69.5 46.8,112.48 46.8,112.49 C220.1 v1(47.59,113.13) ; v1(20.45,58.05) 20.45,56.91 19.32,55.79 R396.2 ; C437.1 117.91,37.63 v1(118.12,37.85) ; R615.2 v1(1.91,80.64) ; R477.1 v1(123.43,26.58) ; R611.1 v1(144.6,57.45) ; v1(29.08,41.53) 30.39,41.53 30.64,41.78 R426.1 ; v1(139.68,52.61) C407.2 139.75,53.43 140.51,53.43 ; R300.2 v1(28.16,90.1) ; R368.2 v1(37.34,59.51) ; v1(149.76,36.75) 149.89,36.88 R610.1 ; v1(44.94,79.04) 44.83,79.16 44.83,79.72 C320.1 ; U91.27 v1(58.8,33.91) ; v1(35.43,39.24) C426.1 36.08,39.78 36.31,40.02 U88.5 ; R493.1 v1(17.8,25.69) ; U75.17 C284.1 v1(55.77,91.35) ; R481.1 v1(35.31,27.83) ; R347.1 v1(5.05,75.95) ; R340.1 v1(42.16,72.6) ; v1(40.34,93.8) C281.1 ; FB19.1 27.48,71.53 v1(27.33,71.37) ; v1(74.42,22.72) 73.91,22.22 73.91,21.13 74.19,20.85 R639.2 ; R365.2 7.15,60.2 6.73,59.78 v1(6.22,59.78) ; C429.2 v1(154.58,39.02) ; R303.1 R306.1 ; R234.2 v1(24.84,110.81) ; v1(15.43,83.34) R616.2 ; C369.1 v1(40.09,74.82) ; R270.1 v1(133.35,100.98) ; R486.2 v1(21.19,25.81)
  BOTTOM w0.305: v1(45.07,98.41) 45.04,98.44 C266.1 ; C35.1 40.75,106.46 40.76,106.44 v1(40.79,106.44)
  BOTTOM w0.381: v1(39.33,115.13) C216.1 39.31,116.1 U64.1 ; C209.1 103.4,120.82 103.4,120.83 U66.16 ; R536.2 v1(130.94,16.66) ; R398.2 v1(119.25,56.78) ; R476.2 v1(126.87,27.57) ; FB21.1 60.08,51.11 60.15,51.18 C411.2 R411.2 ; FB21.1 58.62,50.55 58.62,50.28 v1(58.61,50.27) ; FB21.1 v1(59.18,49.8) ; U64.3 38.01,117.72 v1(37.9,117.6) ; v1(68.67,110.59) FB12.1 v1(69.85,109.49) ; R406.2 v1(130.94,53.1) ; R381.1 R382.1 49.31,69.27 v1(48.95,68.91) ; R504.2 R511.2 R515.2 R520.2 R530.2 ; R504.2 v1(106.76,30.67) ; R504.2 R499.2 R490.2 R475.2 v1(102.06,30.01) ; C408.2 v1(132.57,51.21) ; v1(37.35,72.59) 37.35,73.24 37.06,73.54 R421.1 R420.1 34.11,73.54 34.09,73.51 R419.1 R418.1 ; R537.2 117.29,16.77 v1(117.55,16.51) ; U83.8 C410.2 v1(113.54,49.42) ; v1(101.56,117.81) R226.2 ; R306.1 v1(114.05,85.61) ; v1(46.1,49.33) 45.18,49.33 44.4,48.55 C147.1 ; R309.1 v1(114.05,84.34) ; R384.1 R383.1 23.24,87.92 v1(23.9,88.58) ; R540.2 v1(139.84,16.16) ; R399.2 v1(113.67,56.78) ; R534.2 v1(125.09,16.72) ; C207.2 v1(42.81,122.34) ; R311.1 v1(114.05,83.07) ; R380.2 v1(29.99,58.2)
  BOTTOM w0.508: C286.1 47.41,91.56 v1(47.69,91.84)
  vias: v1(2.54,63.59) v1(4.04,64.63) v1(5.61,63.44) v1(16.51,20.84) v1(16.51,19.7) v1(17.27,20.33) v1(21.08,45.73) v1(21.08,44.72) v1(21.34,58.05) v1(22.1,44.72) v1(22.23,58.05) v1(22.99,58.05) v1(29.08,118.51) v1(29.84,118.51) v1(30.73,118.51) v1(43.94,46.23) v1(48.7,91.84) v1(49.08,90.95) v1(76.07,112.54) v1(76.45,119.01) v1(90.68,132.35) v1(90.68,131.21) v1(91.44,132.35) v1(119.08,61.86) v1(119.08,61.18) v1(139.23,87.82) v1(139.23,86.81) v1(139.23,85.79) v1(139.23,84.77) v1(139.23,83.89) v1(139.23,82.87) v1(139.23,81.85) v1(140.25,87.82) v1(140.25,86.81) v1(140.25,85.79) v1(140.25,84.77) v1(140.25,83.89) v1(140.25,82.87) v1(140.25,81.85) v1(141.26,87.82) v1(141.26,86.81) v1(141.26,85.79) v1(141.26,82.87) v1(141.26,81.85) v1(142.28,87.82) v1(142.28,86.81) v1(142.28,85.79) v1(143.55,87.7) v1(143.55,86.81) v1(143.55,85.79) v1(144.69,87.7) v1(144.69,86.81) v1(144.69,85.79)
VCC_5V0: length 192.6
  TOP w0.254: U2.1 81.51,125.21 81.49,125.22 81.46,125.22 81.21,125.48 81.21,126.25 81.46,126.51 U2.3 ; U30.6 v1(165.78,61.48) ; R111.2 175.73,79.62 175.47,79.37 R109.1
  TOP w0.381: v1(24.79,117.97) FB2.1 v1(25.78,116.98)
  L03_SIG1 w0.254: v1(119.72,76.37) 134.2,76.37 136.65,73.91 138.94,73.91 v1(139.57,74.55)
  L03_SIG1 w0.508: v1(34.75,50.81) 36.04,52.11 36.04,57.32 33.58,59.78 33.58,85.82 28.47,90.92 28.47,103.34 31.75,106.62 31.75,111.01 v1(25.78,116.98)
  L06_PWR2 w0.381: v1(172.37,95.87) 174.92,95.87 175.88,96.82 v1(175.88,101.07)
  BOTTOM w0.254: R314.1 v1(119.72,76.37) ; C539.1 164.64,62.61 161.42,65.84 161.42,69.72 157.4,73.74 140.39,73.74 v1(139.57,74.55) ; U74.5 C271.2 v1(172.37,95.87) ; R266.1 v1(175.88,101.07)
  BOTTOM w0.381: R407.1 161.31,53.75 162.16,54.61 163.05,54.61 167.64,59.2 167.64,60.39 168.53,61.28 ; C539.1 165.55,61.25 v1(165.78,61.48) 166.54,62.24 167.64,62.24 168.53,61.35 168.53,61.28 ; 168.53,61.28 168.88,61.28 169.55,61.95 173.23,61.95 174.42,63.13 v1(174.42,82.46)
  vias: v1(34.24,49.8) v1(82.46,124.47) v1(83.06,124.6) v1(83.22,123.97) v1(83.73,124.47) v1(84.24,123.97) v1(173.41,85.38) v1(173.41,84.37) v1(173.41,83.48) v1(173.41,82.46) v1(174.42,85.38) v1(174.42,84.37) v1(174.42,83.48) v1(175.44,85.38) v1(175.44,84.37) v1(175.44,83.48) v1(175.44,82.46)
VCC_5V0_HSE: length 9.7
  TOP w0.305: J2.A2 72.64,127.24 ; J2.A2 72.67,126.63 72.97,126.33 72.97,126 73,125.97 ; J2.A2 72.29,126.28 72.29,125.95 ; 72.64,127.24 73.91,127.24 ; 72.64,127.24 71.98,127.24 J2.A3 ; J2.A1 73.94,126.63 74.24,126.33 74.24,125.95 ; J2.A1 73.91,127.24 ; J2.A1 73.89,126.63 73.58,126.33 73.58,125.97 ; 73.91,127.24 74.7,127.24 ; J2.A3 71.12,126.38 71.12,125.95 ; J2.A3 71.4,126.63 71.7,126.33 71.7,125.95
VCC_CAN: length 16.3
  TOP w0.381: 13.34,120.38 13.34,119.27 13.19,119.12 C23.2 14.09,118.63 15.75,116.98 FB2.2 23.39,118.33 C24.2 23.09,119.12 23.24,119.27 U4.3
VCC_CORE_EN: length 43.1
  TOP w0.147: R696.1 120.36,102.96 120.37,102.95 C540.1 121.59,102.95 v1(121.72,102.82)
  TOP w0.254: TP24.1 v1(135.27,72.3) R584.2
  BOTTOM w0.254: v1(121.72,102.82) 121.19,102.82 120.94,102.57 120.94,91.97 122.36,90.54 126.82,90.54 130.43,86.93 130.43,77.9 133.76,74.57 133.76,73.66 135.11,72.3 v1(135.27,72.3)
VCC_CORE_FB: length 3.9
  TOP w0.254: U25.2 135.38,75.6 135.39,75.61 R117.2 R118.2 C96.2
VCC_CORE_PG: length 67.8
  TOP w0.147: U104.2 115.19,105.31 115.46,105.58 116.78,105.58 117.89,106.69 123.83,106.69 124.93,105.59 124.93,102.93 125.74,102.13 127.38,102.13 129.2,103.95 130.64,103.95 131.02,103.57 U102.2 131.02,101.74 131.01,101.74 v1(131.01,101.29)
  TOP w0.254: v1(134.36,73.93) R123.1 133.33,74.22 U25.8
  BOTTOM w0.254: v1(131.01,101.29) 127.67,101.29 125.13,98.74 123.42,98.74 121.81,97.13 121.81,95.22 123.52,93.51 123.52,91.9 124.4,91.02 127.2,91.02 134.83,83.39 R312.2 134.83,80.19 135.42,79.6 135.42,74.98 v1(134.36,73.93)
VCC_LCD: length 8.5
  BOTTOM w0.203: 5.84,14.91 5.84,15.51 5.54,15.81 J36.1
  BOTTOM w0.254: TP100.1 10.12,11.79 C474.1 8.43,11.79 5.84,14.38 5.84,14.91
VCC_LM5140: length 13.3
  TOP w0.305: U30.16 161.68,66.34 C107.1 160.87,70.2 D4.2 ; D5.2 162.27,70.2 C108.1 162.18,67.05 U30.15
VDD1V8_CLKBUF: length 7.7
  TOP w0.381: v1(58.1,102.57) 58.44,102.9 C538.2
  TOP w0.508: C536.2 v1(58.44,109.87) ; C537.2 v1(60.44,109.87)
  BOTTOM w0.147: U70.19 60.44,102.9 v1(60.58,102.76)
  BOTTOM w0.254: C537.2 v1(60.44,109.87) ; C536.2 v1(58.44,109.87)
  BOTTOM w0.305: v1(58.1,102.57) 58.44,102.9 C538.2
VDD1V8_PG: length 165.9
  TOP w0.147: U33.5 R143.1 138.96,57.63 140.08,58.76 143.95,58.76 v1(144.27,58.43)
  TOP w0.254: v1(132.46,63.64) 132.61,63.79 R127.2
  L03_SIG1 w0.091: v1(101.45,125.02) 102.91,126.47 115.28,126.47 120.72,121.03 132.27,121.03 133.27,120.03 v1(148.72,120.03) 149.24,120.55 153.08,120.55 154.41,119.22 154.41,105.22 149.86,100.67 149.86,89.68 146.85,86.66 146.85,60.37 144.91,58.43 v1(144.27,58.43)
  BOTTOM w0.147: R581.2 97.11,118.76 97.36,119.01 97.36,120.31 97.03,120.64 97.03,122.77 98.35,124.09 100.52,124.09 v1(101.45,125.02) ; v1(148.72,120.03) TP50.1 146.56,119.64 146.05,119.64 ; C403.1 140.1,57.2 140.57,57.68 140.57,58.17 141.1,58.69 143.56,58.69 143.82,58.43 v1(144.27,58.43) 144.27,59.44 143.25,60.47 138.67,60.47 135.49,63.64 v1(132.46,63.64)
  BOTTOM w0.254: 146.05,119.64 U65.2
VDD3V3_CLKBUF: length 16.9
  TOP w0.254: v1(66.17,104.15) R50.1 R55.2
  BOTTOM w0.14: 73.69,106.89 73.66,106.87 73.66,106.81
  BOTTOM w0.254: U70.10 63.1,107.56 63.52,107.98 63.52,109 ; C234.1 73.69,106.83 73.66,106.81 U71.4 ; R255.1 66.82,104.81 v1(66.17,104.15)
  BOTTOM w0.381: C34.2 C226.2 C225.2 66.78,109 FB12.2 67.27,110.29 v1(66.97,110.59) ; U71.4 v1(75.05,105.81) ; v1(53.34,106.95) R248.1 R253.2 ; R243.2 v1(53.34,108.22)
VDD_0V85: length 0.9
  TOP w0.381: 154.94,107.46 155.11,107.29 U12.8
VDD_0V85_EN: length 46.2
  TOP w0.147: v1(120.53,110.88) 118.11,110.88 116.14,108.91 U104.4
  TOP w0.254: R57.1 153.78,101.89 v1(153.54,102.12)
  BOTTOM w0.147: v1(153.54,102.12) 151.77,103.9 147.76,103.9 144.86,106.8 140.77,106.8 140.34,106.37 122.79,106.37 120.53,108.63 v1(120.53,110.88)
VDD_0V85_PG: length 56.8
  TOP w0.147: v1(122.76,109.02) 122.43,109.02 122.13,108.72 U103.2 ; R20.2 v1(158.73,119.29)
  TOP w0.254: R58.1 155.76,102.92 v1(155.76,103.52) U12.2
  BOTTOM w0.147: v1(158.73,119.29) 158.73,111.74 157.76,110.77 157.76,105.52 v1(155.76,103.52) 154.91,104.37 147.71,104.37 144.98,107.09 140.65,107.09 140.25,106.69 124.45,106.69 122.76,108.38 v1(122.76,109.02)
VDD_1V0: length 16.6
  TOP w0.254: U15.24 41.99,96.79 41.91,96.71 C51.1 ; U15.31 43.95,101.48 44.22,101.21 44.61,101.21 45.07,100.76 C41.1 v1(45.07,99.87) ; U15.42 39.49,105.4 38.84,106.06 C36.1 ; U15.6 v1(34.9,101.48) C39.1
  TOP w0.305: C36.1 39.37,106.46 v1(39.45,106.38) ; C51.1 v1(42.65,96.26)
  BOTTOM w0.147: 44.26,93.58 44.8,93.03 U77.1
  BOTTOM w0.254: C41.1 v1(45.07,99.87) ; C36.1 39.37,106.46 v1(39.45,106.38) ; v1(48.34,100.6) C263.1 v1(47.46,101.39) ; C39.1 v1(34.9,101.48)
  BOTTOM w0.305: C51.1 v1(42.65,96.26)
VDD_1V1: length 26.3
  TOP w0.254: U20.6 v1(34.78,82.12) C76.1 ; v1(42.34,61.05) 41.69,61.05 C124.1 ; C110.1 v1(44.82,67.61) ; U20.31 44.22,82.12 44.43,81.91 44.43,81.78 44.94,81.27 C78.1 v1(44.94,80.51) ; C112.1 v1(34.65,66) ; v1(42.47,87.06) C68.1 41.78,86.88 41.55,86.65 41.55,86.65 41.07,86.17 41.07,86.17 40.87,85.97 U20.39 ; v1(47.59,66.35) C105.1 v1(48.46,67.13) ; U32.3 18.52,61.39 18.25,61.66 18.25,62.5
  BOTTOM w0.254: v1(42.34,61.05) C401.1 41.66,61.36 41.02,62 40.95,62 40.76,62.19 40.76,62.38 40.74,62.4 U80.39 ; U80.31 44.57,66 44.82,66.24 C110.1 v1(44.82,67.61) ; C78.1 v1(44.94,80.51) ; v1(48.59,80.98) C316.1 v1(47.71,81.77) ; v1(17.91,64.53) 18.18,64.26 R361.1 ; C76.1 v1(34.78,82.12) ; C293.1 42.44,87.03 v1(42.47,87.06) ; C112.1 v1(34.65,66) U80.6
  vias: v1(16.89,64.53) v1(16.89,63.51) v1(17.91,63.51)
VDD_2V5: length 20.6
  TOP w0.254: C80.1 v1(34.78,80.62) U20.9 ; v1(31.24,68.3) C111.1 v1(30.37,67.52) ; C73.1 v1(34.78,83.62) U20.3 ; U15.9 v1(34.9,99.98) C43.1 ; C106.1 v1(34.65,67.5) ; U9.3 33.55,114.71 33.69,114.57 C28.1 ; C114.1 v1(34.65,64.5) ; U15.3 v1(34.9,102.98) C38.1
  BOTTOM w0.254: C73.1 v1(34.78,83.62) ; R232.1 33.89,112.3 v1(34.16,112.03) ; U80.9 v1(34.65,67.5) C106.1 ; U80.3 v1(34.65,64.5) C114.1 ; v1(30.62,99.96) C258.1 v1(31.5,99.18) ; C80.1 v1(34.78,80.62) ; v1(31.37,79.81) C305.1 v1(30.49,80.6) ; C38.1 v1(34.9,102.98) ; C43.1 v1(34.9,99.98)
  vias: v1(34.16,113.04) v1(35.18,113.04) v1(35.18,112.03) v1(36.2,113.04) v1(36.2,112.03) v1(37.21,113.04) v1(37.21,112.03)
VDD_2V8: length 44
  TOP w0.508: v1(6.5,18.14) 6.5,17.51 9.87,14.14 20.7,14.14 TP99.1
  BOTTOM w0.254: v1(6.5,18.14) C463.2 6.44,18.81 J36.7 ; U100.1 15.69,16.18 C471.1
  BOTTOM w0.508: R556.1 16.02,12.95 18.32,15.25 18.54,15.25 19.18,14.62 19.18,14.38 21.6,11.95 TP99.1 24.28,13.35 27.3,13.35 28.32,14.37 R538.1
VDD_CORE: length 103.7
  TOP w0.254: U23.L12 v1(91.46,75.9) ; U23.M11 v1(89.86,77.5) ; U23.N10 v1(89.06,78.3) ; U23.K11 v1(92.26,77.5) ; v1(134.37,79.01) 136.77,79.01 138.58,77.2 C96.1 R118.1 ; U23.L8 v1(91.46,79.9) ; U23.P9 v1(88.26,79.1) ; U23.N8 v1(89.06,79.9) ; U23.K9 v1(92.26,79.1) ; U23.M9 v1(89.86,79.1) ; U23.J10 v1(93.06,78.3) ; U23.J12 v1(93.06,75.9)
  L05_PWR1 w0.114: v1(88.26,79.1) 87.86,79.5 86.42,79.5 86.26,79.67 86.26,82.14 86.26,82.14 86.26,85.11 89.41,88.26 98.3,88.26 103.82,93.78 103.82,96.14 104.71,97.03 105.65,97.03 105.84,97.22 TP55.1 ; v1(88.26,79.1) 88.27,79.11 ; v1(88.26,79.1) 88.58,78.78 ; 88.27,79.11 88.62,79.11 88.65,79.14 ; 88.27,79.11 88.6,79.44
  L06_PWR2 w0.114: v1(134.37,79.01) 131.26,79.01 129.23,76.98 117.86,76.98 117.2,77.64 113.49,77.64 113.16,77.31 108.97,77.31 108.53,76.88 108.53,76.62 106.48,74.56 106.15,74.56 104.5,72.91 99.26,72.91 98.27,73.9 93.62,73.9 93.46,74.07 93.46,75.5 v1(93.06,75.9)
  BOTTOM w0.254: v1(124.68,96.32) 124.75,96.39 R284.1 ; C339.1 89.74,77.62 v1(89.86,77.5) ; v1(91.46,79.9) 91.58,80.02 C318.1 ; C345.1 v1(92.26,77.5) ; v1(93.06,78.3) 93.18,78.42 C329.1 ; R298.1 108.45,98.25 107.85,97.65 106.35,97.65 TP55.1 ; C315.1 88.9,80.06 v1(89.06,79.9) ; v1(92.26,79.1) 92.14,79.22 C324.1 ; v1(88.26,79.1) 88.38,79.22 C325.1 ; C332.1 89.18,78.42 v1(89.06,78.3) ; v1(91.46,75.9) 91.34,76.02 C354.1 ; v1(89.86,79.1) 89.98,79.22 C323.1 ; C352.1 v1(93.06,75.9)
  vias: v1(101.26,83.26) v1(101.28,82.02) v1(101.91,82.01) v1(102.49,85.72) v1(102.49,84.45) v1(102.49,83.19) v1(102.59,85.06) v1(121.87,93.11) v1(121.87,91.89) v1(122.94,93.11) v1(122.94,91.89) v1(123.44,89.93) v1(123.44,88.79) v1(123.44,84.47) v1(123.7,87.52) v1(123.7,86.5) v1(123.7,85.49) v1(124.42,94.92) v1(124.46,89.93) v1(124.46,88.79) v1(124.46,84.47) v1(124.71,87.52) v1(124.71,86.5) v1(124.71,85.49) v1(125.48,84.47)
VDD_DDR4: length 36.5
  TOP w0.152: U13.J8 92.8,103.35 92.16,103.35 v1(91.82,103.01)
  TOP w0.254: U23.F7 v1(95.46,80.7) ; R67.2 86.52,98.37 86.7,98.55 v1(87.21,98.55) ; U13.J9 U13.J8 ; U23.L6 v1(91.46,81.5) ; v1(94.4,97.75) 94.84,98.19 96.77,98.19 97.01,98.42 R69.2 ; U23.K7 v1(92.26,80.7) ; U23.H7 v1(93.86,80.7) ; v1(98.62,101.03) R63.2 ; U13.L9 94.46,102.15 v1(94.87,101.74) ; U23.J6 v1(93.06,81.5) ; U23.G6 v1(94.66,81.5) ; U23.J8 v1(93.06,79.9)
  TOP w0.381: U13.A1 v1(87.21,110.55) ; U13.T9 v1(94.4,97.75) ; U13.G1 v1(87.21,105.75) ; U13.D1 v1(87.21,108.15) ; U13.G9 v1(94.4,105.75) ; U13.G7 v1(92.8,105.75) ; U13.F8 v1(93.6,106.55) ; U13.B9 v1(94.4,109.75) ; U13.C1 v1(87.21,108.95) ; v1(87.21,98.55) U13.R1 ; U13.L1 v1(87.21,101.75) ; U13.F2 v1(88.01,106.55) ; U13.J2 v1(88.01,103.35) ; U13.D9 v1(94.4,108.15) ; U13.B3 v1(88.81,109.75) ; U13.A9 v1(94.4,110.55) ; U13.J1 v1(87.21,103.35)
  BOTTOM w0.203: 75.21,117.32 C213.2
  BOTTOM w0.254: v1(94.4,109.75) 94.52,109.63 C229.1 95.17,109.63 95.45,109.91 C230.1 ; v1(93.6,106.55) 93.72,106.67 C236.1 ; v1(88.81,109.75) 88.69,109.87 C224.1 ; C230.1 v1(96.27,110.89) ; C230.1 v1(97.24,109.91) ; C241.1 92.92,105.87 v1(92.8,105.75) ; v1(87.21,108.15) 87.09,108.03 C233.1 ; C222.1 94.28,110.67 v1(94.4,110.55) ; C302.1 93.18,81.62 v1(93.06,81.5) ; C223.1 87.33,110.67 v1(87.21,110.55) ; v1(93.86,80.7) 93.74,80.82 C310.1 ; C303.1 91.58,81.62 v1(91.46,81.5) 91.05,81.5 C308.1 ; C239.1 87.89,106.67 v1(88.01,106.55) ; C307.1 94.78,81.38 v1(94.66,81.5) ; v1(87.21,105.75) 87.09,105.63 C242.1 ; C268.1 87.09,98.43 v1(87.21,98.55) ; C232.1 94.52,108.03 v1(94.4,108.15) ; C248.2 v1(99.82,103.01) ; U68.1 75.21,117.32 ; C314.1 95.58,80.58 v1(95.46,80.7) ; v1(87.21,103.35) 87.09,103.23 C250.1 ; C311.1 92.14,80.82 v1(92.26,80.7) ; v1(93.06,79.9) 93.18,80.02 C317.1
  BOTTOM w0.381: C294.1 98.93,87.14
  vias: v1(75.82,117.87) v1(82.42,118.76) v1(82.42,117.74) v1(82.42,116.73) v1(82.42,115.71) v1(83.44,118.76) v1(83.44,117.74) v1(83.44,116.73) v1(83.44,115.71) v1(84.45,118.76) v1(84.45,117.74) v1(84.45,116.73) v1(84.45,115.71) v1(98.32,87.52) v1(98.35,91.59) v1(98.37,90.57)
VDD_DLL_MMC0: length 29
  TOP w0.254: U23.H14 v1(93.86,74.3)
  L06_PWR2 w0.381: v1(113,71.08) 112.25,70.33 108.41,70.33 107.32,69.25 107.32,68.44 106.05,67.17 103.39,67.17 102.81,66.6 101.65,66.6 v1(101.07,66.01)
  L08_SIG2 w0.114: v1(93.86,74.3) 94.24,73.92 94.24,69.88 94.46,69.66
  L08_SIG2 w0.381: v1(101.07,66.01) 101.12,66.07 101.12,67.01 100.4,67.72 99.5,67.72 97.56,69.66 94.46,69.66
  BOTTOM w0.254: v1(93.86,74.3) 93.86,74.16 C373.1
VDD_MMC1: length 143
  TOP w0.254: U23.H15 v1(93.86,73.5)
  TOP w0.381: C184.1 41.43,23.28 41.4,23.31 FB9.1 ; C184.1 v1(40.01,21.99) ; C184.1 v1(41.43,20.49)
  L06_PWR2 w0.114: 98.35,72.3 98.37,72.3 98.37,72.33 ; 98.35,72.3 98.37,72.33 ; 98.35,72.3 93.67,72.3 93.46,72.52 93.46,73.1 v1(93.86,73.5) 94.26,73.1 98.26,73.1 98.62,72.74 98.62,72.58 98.37,72.33
  L06_PWR2 w0.381: 109.53,61.86 109.35,62.04 v1(109.35,62.3) ; 109.53,61.86 v1(109.8,61.86) ; 109.53,61.86 108.75,61.86 101.13,54.24 89.41,54.24 85.43,58.22 82.97,58.22 80.14,61.05 80.14,62.78 76.5,66.41 69.75,66.41 69.24,65.9 69.24,62.75 68.48,61.99 68.48,57.8 62.38,51.7 62.38,29.22 61.37,28.21 52.25,28.21 51,26.96 51,21.55 49,19.55 42.34,19.55 42.04,19.85 ; v1(105.08,72.51) 98.81,72.51 98.73,72.58 98.62,72.58
  BOTTOM w0.254: C382.1 v1(93.86,73.5)
  BOTTOM w0.381: C119.1 105.11,72.48 v1(105.08,72.51)
VDD_MMC1_SD: length 4.1
  TOP w0.381: v1(41.26,27.17) 41.26,26.13 FB9.2
  BOTTOM w0.254: J37.4 41.2,25.37 41.26,25.43 C451.1 v1(41.26,27.17)
VDDA_1V8: length 26.2
  TOP w0.254: U23.G11 v1(94.66,77.5) ; U23.L11 v1(90.66,77.5) ; U23.H13 v1(93.86,75.1)
  L08_SIG2 w0.254: v1(91.77,61.81) 92.31,62.36 95.25,62.36 95.5,62.61 95.5,66.04 94.73,66.82 93.2,66.82 90.31,69.71 90.31,76.36 90.42,76.47 90.34,76.55 90.34,77.18 v1(90.66,77.5)
  BOTTOM w0.254: v1(71.54,83.85) 71.69,83.7 FB15.1 ; v1(94.66,77.5) 94.79,77.37 C338.1 ; C342.1 90.65,77.51 v1(90.66,77.5) C346.1
  vias: v1(90.68,56.33) v1(90.81,55.26) v1(91.77,60.59) v1(109.1,83.31) v1(109.1,82.09) v1(110.11,83.31) v1(110.11,82.09) v1(110.74,69.72) v1(110.74,68.63) v1(111.75,69.72) v1(111.75,68.63) v1(126.87,72.4) v1(126.87,71.39) v1(126.87,70.37) v1(127.89,72.4) v1(127.89,71.39) v1(127.89,70.37) v1(128.91,72.4) v1(128.91,71.39) v1(128.91,70.37) v1(129.92,72.4) v1(129.92,71.39) v1(129.92,70.37)
VDDA_1V8_MCU: length 0.8
  TOP w0.254: U23.K12 v1(92.26,75.9)
  BOTTOM w0.254: C353.1 v1(92.26,75.9)
  vias: v1(108.96,72.28) v1(108.96,71.07) v1(109.97,72.28) v1(109.97,71.07)
VDDA_1V8_SERDES: length 1.4
  TOP w0.254: U23.R14 v1(87.46,74.3)
  L05_PWR1 w0.381: v1(87.46,74.3) 87.46,74.27 87.25,74.06
  BOTTOM w0.254: R632.2 v1(81.33,68.66)
  vias: v1(88.99,64.55) v1(90.62,64.53)
VDDA_1V8_USB0: length 2.2
  TOP w0.254: U23.R15 v1(87.46,73.5)
  BOTTOM w0.254: 89.03,63.55 88.61,63.13 88.01,63.13 87.76,62.88 C399.1
  vias: v1(91.77,64.56) v1(91.77,63.34)
VDDA_ADC: length 131.7
  TOP w0.254: J3.4 105.92,129.43 103.5,129.43 102.6,128.52 C4.2 ; U23.J13 v1(93.06,75.1)
  TOP w0.381: C7.2 124.95,126.96 124.97,126.98 J3.17 ; v1(102.49,125.11) 102.6,125.22 C4.2
  L05_PWR1 w0.381: v1(110.34,88.38) 108.51,86.55 108.51,74.96 v1(109.97,73.5)
  L06_PWR2 w0.114: 89.98,69.61 89.46,70.13 89.46,74.51 89.66,74.7 92.66,74.7 v1(93.06,75.1)
  L06_PWR2 w0.381: v1(112.01,73.5) 112.01,72.53 111.19,71.7 108.79,71.7 105.95,68.87 105.95,68.44 105.36,67.84 103.2,67.84 102.57,67.21 100.32,67.21 v1(99.5,66.38) 98.67,67.21 95.08,67.21 94.4,67.89 91.7,67.89 89.98,69.61
  BOTTOM w0.254: v1(93.06,75.1) 93.05,75.11 92.89,75.11 92.84,75.16 C368.1 ; R699.2 99.66,66.54 v1(99.5,66.38) ; J3.17 126.24,129.43 126.24,131.79 125.98,132.04 108.53,132.04 J3.4
  BOTTOM w0.381: v1(102.49,125.11) 102.49,124.08 104.63,121.93 106.93,121.93 107.54,121.33 107.54,104.65 110.34,101.85 110.34,92.7 109.22,91.58 109.22,89.5 v1(110.34,88.38)
VDDA_CORE: length 110.4
  TOP w0.147: U23.K13 v1(92.26,75.1)
  L03_SIG1 w0.381: v1(118.36,70.37) 119.43,71.44 119.43,75.22 117.68,76.98 117.68,79.54 115.01,82.21 115.01,85.73 111.95,88.79 111.95,98.5 v1(113.79,100.34)
  L03_SIG1 w0.508: v1(113.79,100.34) v1(115.01,100.34)
  L05_PWR1 w0.381: v1(71.86,79.8) 76.49,79.8 76.72,80.02 77.99,80.02 v1(79.88,81.92) 80.45,81.92 80.49,81.88 82.25,81.88 89.03,88.66 98.09,88.66 103.25,93.82 103.25,96.39 104.62,97.76 104.62,98.67 105.72,99.76 113.21,99.76 v1(113.79,100.34)
  L06_PWR2 w0.114: v1(92.26,75.1) 91.86,75.5 89.69,75.5 89.46,75.27 89.46,74.94 89.22,74.7 88.89,74.7 88.66,74.47 88.66,73.31 88.45,73.1 88.09,73.1 87.86,73.34 87.86,73.71 87.67,73.9 83.29,73.9 82.84,74.36 82.84,74.38
  L06_PWR2 w0.381: 82.84,74.38 81.81,74.38 79.63,76.57 79.63,81.09 79.88,81.34 v1(79.88,81.92)
  vias: v1(70.68,79.8) v1(117.47,70.37)
VDDA_LM5140: length 31.1
  TOP w0.254: R701.1 162.8,55.59 162.48,55.91 v1(162.48,56.39) 161.71,56.39 C138.1 ; R134.2 167.77,61.27 v1(167.6,61.43) ; R693.1 v1(159.44,54.07) ; v1(156.59,59.45) 157.69,59.45 158.22,59.98 U30.28 ; U30.36 162.18,57.36 v1(162.5,57.04) 162.04,57.04 C138.1 ; C138.1 161.18,56.92 U30.34 ; U30.3 v1(165.78,59.98)
  BOTTOM w0.254: v1(156.59,59.45) 156.16,59.02 156.16,55.91 158,54.07 v1(159.44,54.07) 159.81,54.07 161.49,55.75 161.49,56.03 v1(162.5,57.04) 163.57,57.04 165.78,59.24 v1(165.78,59.98) 166.52,60.72 166.89,60.72 v1(167.6,61.43)
VDDA_PLL0: length 14.5
  TOP w0.254: U23.N12 v1(89.06,75.9)
  L03_SIG1 w0.254: v1(89.06,75.9) 88.27,76.7 83.26,76.7 v1(78,81.96)
  BOTTOM w0.254: v1(89.06,75.9) 89.18,76.02 C355.1
VDDA_PLL1: length 18.8
  TOP w0.254: U23.H9 v1(93.86,79.1)
  L03_SIG1 w0.114: 93.48,80.06 93.48,79.49 v1(93.86,79.1) 94.24,79.49 98.38,79.49 98.78,79.89 98.38,80.29 93.7,80.29 93.48,80.06
  L03_SIG1 w0.381: 98.78,79.89 103.23,79.89 v1(103.99,79.13)
  BOTTOM w0.254: v1(93.86,79.1) 93.98,79.22 C322.1 ; C300.1 103.74,78.88 v1(103.99,79.13)
VDDA_PLL2: length 19.1
  TOP w0.254: U23.J11 v1(93.06,77.5)
  L06_PWR2 w0.254: 98.74,77.71 98.02,76.99 93.57,76.99 v1(93.06,77.5)
  L06_PWR2 w0.381: 98.74,77.71 99.57,78.54 99.57,79.85 101.02,81.3 102.25,81.3 103.12,82.17 103.12,83.74 v1(105.46,86.07)
  BOTTOM w0.254: C347.1 93.18,77.38 v1(93.06,77.5)
VDDA_SYS_MON: length 31.6
  TOP w0.147: U23.K10 v1(92.26,78.3)
  L08_SIG2 w0.091: v1(114.25,77.05) 113.21,77.05 110.72,74.56 100.4,74.56 97.9,77.07 97.7,77.07 97.46,77.31 97.46,77.67 97.22,77.9 96.9,77.9 96.66,78.14 96.66,78.46 96.42,78.7 94.48,78.7 94.24,78.46 94.24,78.12 94.03,77.91 92.65,77.91 v1(92.26,78.3)
  BOTTOM w0.147: v1(114.25,77.05) 115.36,77.05 116.01,76.41 R315.1 R314.2 117.8,75.77 117.87,75.7 R604.2
VDDAR_0P85_SERDES0: length 3.5
  TOP w0.254: U23.P13 v1(88.26,75.1) ; U23.P12 v1(88.26,75.9) ; U23.P11 v1(88.26,77.5)
  L05_PWR1 w0.381: v1(88.26,75.9) v1(88.26,75.1)
  BOTTOM w0.254: C344.1 88.38,77.38 v1(88.26,77.5) ; C362.1 88.38,75.22 v1(88.26,75.1) ; C356.1 88.14,76.02 v1(88.26,75.9)
  vias: v1(73.15,76.71) v1(73.81,76.63)
VDDAR_0P85_USB0: length 14.6
  TOP w0.254: U23.T12 v1(86.66,75.9)
  L05_PWR1 w0.381: v1(86.66,75.9) 86.43,76.13 86.43,76.14 86.1,76.48 86.09,76.48 85.97,76.6 82.38,76.6 v1(81.77,75.98) 81.15,75.36 77.06,75.36 77.04,75.34 75.59,75.34 v1(75.18,75.74) 74.98,75.95 v1(74.98,76.4)
  BOTTOM w0.254: v1(86.66,75.9) 86.63,75.93 C350.1 ; C358.1 81.95,76.17 v1(81.77,75.98)
VDDAR_CORE: length 48.2
  L03_SIG1 w0.091: v1(115.77,91.56) 117.27,91.56 117.6,91.89 117.6,93.39 121.41,97.2 125.6,97.2 126.01,97.6 131.67,97.6 137.54,103.47 137.54,104.38 142.44,109.29 143.81,109.29 144.37,109.84 148.77,109.84 151.64,106.97 v1(153.06,106.97)
  BOTTOM w0.147: R44.1 v1(153.06,106.97)
  vias: v1(114.73,92.62) v1(114.73,91.51) v1(115.72,92.67) v1(145.67,115.46) v1(145.67,114.44) v1(145.67,113.43) v1(146.69,115.46) v1(146.69,114.44) v1(146.69,113.43) v1(146.81,112.41) v1(147.7,115.46) v1(147.7,114.44) v1(147.7,113.43) v1(147.83,112.41)
VDDAR_SENSE: length 4.1
  BOTTOM w0.147: U76.3 128.48,94.73 127.8,95.41 R282.2 R283.1 R284.2
VDDB_3V3_DISPLAY: length 22.7
  TOP w0.508: v1(22.86,22.49) 8.89,22.49 6.53,20.13 v1(6.53,19.48)
  BOTTOM w0.254: J36.10 6.26,20.31 C462.2 6.5,19.55 6.53,19.52 v1(6.53,19.48)
  BOTTOM w0.508: U99.1 23.73,22.28 C455.1 23.52,22.49 v1(22.86,22.49)
VDDC_1V2: length 26.4
  TOP w0.203: 162,24.08 161.75,24.33 U59.87 ; U59.115 v1(151.95,28.27)
  TOP w0.381: 162,24.08 163.82,22.26 C185.2 C186.1 C187.1
  BOTTOM w0.254: v1(151.95,28.27) 151.95,27.26 156.34,22.87 v1(167.77,22.87)
VDDIM: length 4.4
  TOP w0.094: v1(115.06,39.35) 115.31,39.6 115.87,39.6 U44.C2 115.89,39.12 115.76,39.12 115.75,39.11 115.49,39.11 115.49,39.12 115.29,39.12 v1(115.06,39.35)
  BOTTOM w0.254: C428.1 v1(115.06,39.35) C427.1
VDDO12: length 6.3
  TOP w0.279: 50.88,57.69 U105.16
  TOP w0.381: 50.88,57.69 50.43,58.14 C526.1 C523.1 C519.1 50.43,61.82 50.41,61.84 FL17.3
VDDO34: length 6.5
  TOP w0.279: U105.15 51.38,57.7 51.48,57.8
  TOP w0.305: C525.1 51.48,57.8
  TOP w0.381: FL18.3 51.48,61.95 C517.1 C522.1 C525.1
VDDR_CORE: length 78.8
  TOP w0.254: U23.L10 v1(91.46,78.3) ; U23.M13 v1(89.86,75.1)
  L03_SIG1 w0.254: v1(117.42,83.43) 118.36,84.37 118.36,91.63 120.83,94.1 124.82,94.1 v1(127.76,97.04)
  L05_PWR1 w0.114: TP61.1 119.38,79.85 119.63,80.1 120.68,80.1 121.21,79.57 121.21,79.01 118.87,76.67 118.87,74.89 111.68,67.71 111.51,67.71 108.92,65.12 97.94,65.12 95.02,68.04 90.81,68.04 89.94,68.9 89.1,68.9 88.66,69.34 88.66,72.07 88.66,72.07 88.66,74.48 88.89,74.7 89.46,74.7 v1(89.86,75.1)
  L05_PWR1 w0.254: 89.92,75.1 89.96,75.1 90.25,74.82 ; 89.92,75.1 v1(89.86,75.1) 89.86,75.15 89.53,75.48 ; 89.92,75.1 90.25,75.43
  BOTTOM w0.254: C330.1 91.34,78.42 v1(91.46,78.3) ; C475.1 89.94,75.02 v1(89.86,75.1) ; R282.1 v1(127.76,97.04)
  BOTTOM w0.381: 117.44,77.97 117.44,77.99 117.91,78.46 ; TP61.1 118.45,79.01 117.91,78.46 ; 117.91,78.46 117.9,78.46 R307.1
  vias: v1(110.11,80.1) v1(110.11,79.36) v1(111.33,80.1) v1(111.38,79.39) v1(116.66,83.4) v1(116.66,82.72) v1(117.47,82.69)
VDDR_VTT: length 21.9
  TOP w0.147: R86.2 R85.2
  TOP w0.203: v1(78.57,117.32) 78.57,120.11 79.76,121.3 v1(79.76,122.32)
  TOP w0.254: R46.2 83.59,104.95 v1(82.36,106.19)
  TOP w0.508: v1(85.16,93.43) 85.16,94.22 ; v1(93.15,92.47) 93.15,93.94
  BOTTOM w0.203: U68.3 77.34,118 77.72,118.38 ; U68.5 v1(78.57,117.32)
  BOTTOM w0.254: R274.2 R271.2 v1(101.35,100.47) ; R256.2 100.33,104.28 v1(101.35,103.27)
  vias: v1(78.49,123.59) v1(79.76,123.59) v1(82.17,97.42) v1(82.17,95.65)
VDDSHV_SD_IO: length 12
  TOP w0.254: TP39.1 34.56,25.92 36.1,27.47 36.47,27.47 v1(36.83,27.83) ; v1(91.46,74.3) U23.L15 v1(91.46,73.5) ; v1(91.46,74.3) U23.L14 ; v1(91.46,74.3) U23.K15 v1(92.26,73.5) ; U49.10 v1(46.61,30.62)
  BOTTOM w0.254: R483.1 v1(45.29,27.7) ; v1(91.46,74.3) 91.45,74.31 C372.1 ; R479.1 v1(38.1,27.83) ; R646.1 46.74,30.62 v1(46.61,30.62) 46.5,30.73 C446.1 ; R484.1 v1(43.94,27.7) ; R485.1 v1(42.55,27.7) ; R480.1 v1(36.83,27.83)
  vias: v1(92.21,66.51)
VIN_MON_PORZ_3V3_PG: length 438.3
  TOP w0.147: R578.2 v1(157.78,55.58) ; U41.3 v1(140.86,39.86)
  TOP w0.254: v1(144.51,91.8) C57.1 144.51,92.64 145.25,93.38 U17.10
  L03_SIG1 w0.091: v1(88.39,131.84) 88.88,131.84 93.85,126.87 93.85,121.3 95.28,119.88 101.02,119.88 103.2,122.06 103.2,125.57 103.89,126.25 115.19,126.25 120.61,120.83 131.79,120.83 133.22,119.39 150.37,119.39 151.06,120.09 153.23,120.09 154.19,119.13 154.19,105.31 149.61,100.73 149.61,93.36 148.05,91.8 v1(144.51,91.8) ; v1(44.69,114.92) 44.69,113.93 46.35,112.27 46.35,101.98 45.56,101.19 45.56,98.19 v1(47.12,96.64) ; v1(24.52,60.89) 25.94,62.31 25.94,67.4 28.74,70.2 28.74,84.49 24.38,88.85 24.38,90.06 20.4,94.05 20.4,116.35 23.36,119.31 26.58,119.31 v1(27.95,117.94)
  L08_SIG2 w0.091: v1(27.95,117.94) 31.92,117.94 33.99,115.87 43.74,115.87 v1(44.69,114.92) ; v1(144.51,91.8) 142.88,90.17 142.88,81.92 138.81,77.85 138.81,71.63 140.84,69.6 140.84,49.15 141.48,48.51 141.48,46.48 140.86,45.86 v1(140.86,39.86) 153.64,52.64 154.83,52.64 v1(157.78,55.58)
  BOTTOM w0.147: v1(144.51,91.8) 158.07,91.8 169.66,103.39 R259.2 171.47,102.81 171.42,102.76 U74.1 ; R588.2 v1(47.12,96.64) ; v1(27.95,117.94) 31.72,117.94 32.4,117.26 R585.2 ; v1(24.52,60.89) 24.52,59.63 23.43,58.55 20.39,58.55 19.79,59.14 R587.2 ; v1(44.69,114.92) 44.02,114.25 37.54,114.25 35.94,115.85 35.94,123.9 38.48,126.44 54.08,126.44 63.04,117.47 72.29,117.47 72.9,118.08 72.9,120.78 79.35,127.23 82.76,127.23 TP45.1 87.89,132.09 88.15,131.84 v1(88.39,131.84)
  BOTTOM w0.254: R586.2 88.74,132.19 v1(88.39,131.84)
ADC0_AIN0: length 117.2
  TOP w0.147: v1(111.67,57.01) 111.67,55.46 107.68,51.47 107.51,51.3 101.22,51.3 99.91,52.6 97.93,52.6 93.99,56.55 93.99,68.81 93.86,68.94 93.86,69.5 U23.G20
  BOTTOM w0.147: v1(111.67,57.01) 111.67,57.58 112.03,57.95 112.03,59.01 115.65,62.63 118.86,62.63 121.67,65.43 121.67,70.86 122.44,71.63 122.44,87.14 118.78,90.8 118.78,122.9 122.43,126.54 J3.15
ADC0_AIN1: length 117
  TOP w0.147: v1(110.62,57.01) 110.62,55.24 107.26,51.89 101.46,51.89 100.16,53.19 98.18,53.19 94.58,56.79 94.58,66.75 94.65,66.82 94.65,69.49 U23.F20
  BOTTOM w0.147: J3.14 118.75,129.55 118.75,127.7 118.49,127.44 118.49,90.67 122.15,87.02 122.15,71.75 121.37,70.98 121.37,65.55 118.74,62.92 115.53,62.92 111.74,59.13 111.74,58.13 v1(110.62,57.01)
ADC0_AIN2: length 119
  TOP w0.147: v1(108.2,58.18) 109.01,57.38 109.01,54.88 106.9,52.77 101.83,52.77 100.52,54.08 98.54,54.08 96.22,56.4 96.22,63.51 95.86,63.87 U23.E21
  BOTTOM w0.147: v1(108.2,58.18) 108.82,58.79 109.73,58.79 115.04,64.1 118.25,64.1 120.19,66.04 120.19,71.47 120.97,72.24 120.97,86.53 117.31,90.19 117.31,121.21 113.09,125.43 113.09,125.44 112,126.54 109.44,126.54 108.6,127.38 108.6,129.57 J3.6
ADC0_AIN3: length 117.3
  TOP w0.147: U23.D20 96.27,69.52 96.27,64.06 96.66,63.67 96.66,56.38 98.53,54.51 108.21,54.51 108.71,55.01 108.71,56.53 v1(108.33,56.91)
  BOTTOM w0.147: v1(108.33,56.91) 108.72,56.52 111.82,56.52 112.33,57.03 112.33,58.89 115.77,62.33 119.21,62.33 122.74,65.85 122.74,87.36 119.1,90.99 119.1,122.67 123.7,127.27 123.7,129.43 J3.18
ADC0_AIN4: length 118.8
  TOP w0.147: v1(110.49,58.31) 111.07,57.73 111.07,55.28 107.38,51.59 101.34,51.59 100.03,52.9 98.06,52.9 94.28,56.67 94.28,68.6 94.26,68.62 U23.G21
  BOTTOM w0.147: v1(110.49,58.31) 110.81,58.63 110.81,59.04 115.28,63.51 118.49,63.51 120.78,65.8 120.78,71.22 121.56,72 121.56,86.77 117.9,90.43 117.9,121.46 113.68,125.68 113.68,129.7 114.68,130.7 J3.10
ADC0_AIN5: length 114.3
  TOP w0.147: U23.F21 95.06,66.78 94.87,66.59 94.87,56.91 98.3,53.49 100.28,53.49 101.58,52.18 107.14,52.18 110.06,55.1 110.06,57.73 v1(109.6,58.18)
  BOTTOM w0.147: J3.7 112.27,126.68 113.39,125.57 113.39,125.56 117.6,121.34 117.6,90.31 121.26,86.65 121.26,72.12 120.49,71.34 120.49,65.92 118.37,63.8 115.16,63.8 110.52,59.16 110.52,59.1 v1(109.6,58.18)
ADC0_AIN6: length 99.5
  TOP w0.147: U23.F19 v1(95.46,70.3)
  BOTTOM w0.114: 97.45,70.7 95.83,70.7 95.46,70.33 v1(95.46,70.3)
  BOTTOM w0.147: 97.45,70.7 97.87,71.12 100.73,71.12 101.37,70.47 101.37,66.54 102.62,65.29 109.08,65.29 109.84,64.53 116.46,64.53 119.9,67.97 119.9,71.59 120.67,72.36 120.67,86.41 117.02,90.06 117.02,121.09 112.8,125.31 112.8,125.32 111.87,126.25 109.1,126.25 J3.3
ADC0_AIN7: length 112.4
  TOP w0.147: U23.E20 95.47,69.52 95.47,63.68 95.86,63.29 95.86,56.34 98.42,53.78 100.4,53.78 101.7,52.48 107.02,52.48 109.6,55.06 v1(109.6,57.04)
  BOTTOM w0.147: v1(109.6,57.04) 110.36,57.8 110.74,57.8 111.45,58.5 111.45,59.25 115.41,63.21 118.62,63.21 121.08,65.67 121.08,71.1 121.85,71.87 121.85,86.89 118.19,90.55 118.19,126.07 117.35,126.91 J3.11
