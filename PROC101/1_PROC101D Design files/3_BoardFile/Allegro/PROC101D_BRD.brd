# Allegro board PROC101D_BRD.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
XDS_USB_DP: length 24.7
  TOP w0.107: J28.3 173.04,23.64 172.82,23.85 172.55,23.85 v1(172.25,23.55) 172,23.8 171.67,23.8 171.54,23.67 171.54,23.26 171.31,23.02 171.03,23.02 170.89,22.88 U58.4 ; U59.94 159.66,27.13 159.56,27.02 158.69,27.02 v1(158.37,27.34)
  BOTTOM w0.107: v1(158.37,27.34) 158.15,27.12 157.79,27.12 157.35,26.68 157.35,25.54 158.4,24.49 166.66,24.49 167.3,23.85 171.95,23.85 v1(172.25,23.55)
XDS_USB_ID: length 22.2
  TOP w0.147: U58.2 v1(169.16,23.38)
  TOP w0.254: J28.4 172.32,22.99 v1(171.96,22.62)
  BOTTOM w0.147: v1(169.16,23.38) 169.93,23.38 170.69,22.62 v1(171.96,22.62) 172.72,22.62 173.23,23.13 173.23,25.03 172.47,25.8 168.54,25.8 166.89,27.44 R478.2
XDS_USB_VBUS: length 6.4
  TOP w0.147: v1(170.43,24.83) 170.43,24.38 170.5,24.31 U58.6
  TOP w0.254: U61.2 166.02,11.9 165.61,12.31 v1(165.61,12.59) ; v1(172.47,25.14) 172.67,24.94 J28.1 ; U61.8 v1(171.03,12.55)
  BOTTOM w0.254: R469.1 143.68,31.34 v1(143.64,31.38) ; v1(162.26,31.38) 162.22,31.34 R467.1
  vias: v1(164.47,13.6) v1(164.59,12.84)
N5126260: length 13.1
  TOP w0.147: U15.13 36.49,97.14 36.39,97.04 v1(35.94,97.04) ; TP11.1 34.28,104.73 v1(35.81,104.73) U15.48
  L03_SIG1 w0.091: v1(35.94,97.04) 35.94,97.48 35.81,97.61 v1(35.81,104.73)
N15202140: length 2.3
  TOP w0.147: U59.95 v1(159.3,27.53)
  BOTTOM w0.147: R478.1 159.39,27.44 v1(159.3,27.53)
N15204440: length 14.2
  TOP w0.254: U61.5 169.95,8.93 169.21,8.19 163.53,8.19 162.94,8.78 162.94,9.52 C198.2 R204.2 v1(162.05,10.81)
  BOTTOM w0.254: v1(162.05,10.81) 162.05,9.84 162.35,9.54 C198.2
N15205319: length 3.2
  TOP w0.147: R200.1 163.31,16.52 163.29,16.5 C193.2 161.95,16.5 161.72,16.73 U59.68
N15212041: length 4.7
  TOP w0.147: R205.1 155.11,12 155.45,12.34 156.49,12.34 157.15,13.01 U59.59
N15239696: length 3.2
  TOP w0.147: v1(160.91,28.84) 160.65,28.58 U59.96
  BOTTOM w0.147: R467.2 C447.2 160.99,28.97 160.91,28.89 v1(160.91,28.84)
N15241750: length 3.2
  TOP w0.147: U59.1 145.25,28.63 v1(145.03,28.84)
  BOTTOM w0.147: R469.2 R468.1 144.91,28.97 v1(145.03,28.84)
N15242949: length 6.6
  TOP w0.147: U59.3 144.21,27.13 143.38,27.95 141.48,27.95 v1(140.95,28.49)
  BOTTOM w0.147: R466.1 v1(140.95,28.49)
N15242980: length 2.7
  TOP w0.147: v1(141.99,28.97) 142.19,29.18 LD22.2
  BOTTOM w0.147: R466.2 141.86,30.17 141.86,29.1 v1(141.99,28.97)
N15243226: length 10.2
  TOP w0.147: v1(140.08,29.22) 140.08,28.59 141.1,27.57 143.26,27.57 144.1,26.73 U59.4
  BOTTOM w0.147: v1(140.08,29.22) 140.08,31 140.82,31.74 R462.1
N15365714: length 4.4
  BOTTOM w0.147: J38.27 70.41,15.12 71.15,15.85 72.48,15.85 72.62,15.99 R543.2
N15365947: length 3.3
  BOTTOM w0.147: J38.30 68.91,14.87 69.82,15.78 69.82,16.07 70.29,16.54 R545.2
N15366015: length 3
  BOTTOM w0.147: R546.2 69.19,15.79 68.41,15.01 J38.31
N15366091: length 2.7
  BOTTOM w0.147: R547.2 68.05,15.26 67.91,15.13 J38.32
N15507744: length 1.6
  TOP w0.147: U43.2 165.74,35.34 C159.2
N15584817: length 2.2
  TOP w0.147: SW2.13 v1(87,28.21)
  BOTTOM w0.147: R508.1 v1(87,28.21)
N15584821: length 2.2
  TOP w0.147: SW2.14 v1(85.73,28.21)
  BOTTOM w0.147: R512.1 v1(85.73,28.21)
N15584825: length 2.2
  TOP w0.147: SW2.15 v1(84.46,28.21)
  BOTTOM w0.147: R517.1 v1(84.46,28.21)
N15584829: length 2.2
  TOP w0.147: SW2.16 v1(83.19,28.21)
  BOTTOM w0.147: R527.1 v1(83.19,28.21)
N15591045: length 2.2
  TOP w0.147: SW2.9 v1(92.07,28.21)
  BOTTOM w0.147: R472.1 v1(92.07,28.21)
N15591049: length 2.2
  TOP w0.147: SW2.10 v1(90.8,28.21)
  BOTTOM w0.147: R487.1 v1(90.8,28.21)
N15591053: length 2.2
  TOP w0.147: SW2.11 v1(89.53,28.21)
  BOTTOM w0.147: R496.1 v1(89.53,28.21)
N15591057: length 2.2
  TOP w0.147: SW2.12 v1(88.27,28.21)
  BOTTOM w0.147: R501.1 v1(88.27,28.21)
N15854407: length 1.9
  TOP w0.147: U14.3 126.62,106.42 R43.1
N15854417: length 5.3
  TOP w0.147: R73.1 126.32,97.91 126.34,97.93 C47.2 126.89,98.52 ; U14.8 126.62,98.79 126.89,98.52 ; 126.89,98.52 127.12,98.75 U14.9
N15854427: length 3.8
  TOP w0.147: U14.10 127.62,98.82 127.87,98.57 C47.1 128.68,97.93 128.7,97.91 R74.1
N15854463: length 1.8
  TOP w0.147: U6.3 R28.1
N15854467: length 7.8
  TOP w0.147: U6.9 150.12,122.05 150.24,121.93 150.5,121.93 150.62,122.06 U6.8 150.62,124.22 150.49,124.35 v1(150.24,124.35)
  BOTTOM w0.147: v1(150.24,124.35) 150.24,123.9 150.18,123.84 C204.2 149.61,122.82 149.29,122.51 R216.1
N15854483: length 6.7
  TOP w0.147: v1(150.24,125.11) 149.62,124.49 U6.10
  BOTTOM w0.147: v1(150.24,125.11) 151.16,124.19 C204.1 151.76,122.82 152.04,122.55 R215.1
N15854545: length 2.8
  TOP w0.147: U11.3 v1(147.19,108.22)
  BOTTOM w0.147: R244.1 146.16,108.22 v1(147.19,108.22)
N15854547: length 1.7
  TOP w0.147: R122.1 138.54,72.93 138.56,72.91 U28.3
N15854553: length 33.1
  TOP w0.147: v1(139.84,107.72) U11.9 142.24,107.72 142.37,107.85 142.37,108.09 142.24,108.22 U11.8
  BOTTOM w0.147: v1(139.84,107.72) 139.51,108.04 139.14,108.04 138.39,107.29 126.15,107.29 125.86,107.58 125.86,112.16 126.62,112.92 127.76,112.92 128.78,113.93 128.78,115.97 129.67,116.85 C214.2 131.08,115.84 R229.1
N15854557: length 10.5
  TOP w0.147: U28.8 138.56,66.44 138.69,66.31 138.95,66.31 139.06,66.42 U28.9 139.06,68.48 v1(138.94,68.59)
  BOTTOM w0.147: R350.1 134.47,68.3 135.96,66.82 138.56,66.82 138.83,67.09 C393.2 138.94,67.56 v1(138.94,68.59)
N15854581: length 9
  TOP w0.147: v1(139.95,68.59) 139.56,68.2 U28.10
  BOTTOM w0.147: v1(139.95,68.59) 139.81,68.45 C393.1 139.81,66.86 139.83,66.84 139.83,66.69 139.57,66.44 135.64,66.44 135.13,66.94 R352.1
N15854603: length 33.7
  TOP w0.147: v1(139.32,107.33) 139.43,107.22 U11.10
  BOTTOM w0.147: v1(139.32,107.33) 138.98,106.99 125.95,106.99 125.35,107.58 125.35,112.28 126.62,113.55 127.64,113.55 128.27,114.19 128.27,116.6 129.41,117.74 131.83,117.74 132.06,117.51 C214.1 132.06,116.18 132.68,115.57 R228.1
N15854737: length 1.8
  TOP w0.147: U1.3 R1.1
N15854741: length 5.7
  TOP w0.147: R11.1 86.36,123.19 U1.8 86.36,125.24 v1(86.74,125.62) 86.86,125.5 U1.9
  BOTTOM w0.147: v1(86.74,125.62) 86.42,125.3 86.42,125.03 86.51,124.94 C203.2
N15854757: length 5.4
  TOP w0.147: v1(87.63,125.62) 87.36,125.35 U1.10 87.36,123.31 87.38,123.29 87.38,123.2 87.52,123.06 R10.1
  BOTTOM w0.147: v1(87.63,125.62) 87.48,125.47 C203.1
N15854857: length 2.1
  TOP w0.254: R12.2 131.7,124.73
N15854859: length 2.4
  TOP w0.254: J4.1 129.16,123.55 129.29,123.42 R13.2
N16248811: length 3.3
  TOP w0.147: R60.1 v1(60.45,102)
  BOTTOM w0.147: U70.20 59.94,103.14 60.07,103.01 60.07,102.38 v1(60.45,102) R60.1
N16248833: length 3.4
  TOP w0.147: R61.1 v1(61.72,102)
  BOTTOM w0.147: R61.1 v1(61.72,102) 61.21,102.5 61.21,102.88 60.94,103.16 U70.18
N16248855: length 6.5
  TOP w0.147: R65.1 v1(62.99,101.23)
  BOTTOM w0.147: U70.17 62.24,103.76 62.99,103.01 v1(62.99,101.23) R65.1 63.61,100.45 63.72,100.34 R272.1
N16248877: length 2.7
  BOTTOM w0.147: R235.1 61.44,110.11 U70.8
N16248899: length 2.4
  BOTTOM w0.147: U70.7 60.94,110.43 61.21,110.7 R236.1
N16248921: length 2.3
  BOTTOM w0.147: U70.5 59.94,110.7 59.94,110.7 R237.1
N16248943: length 2.4
  BOTTOM w0.147: U70.3 58.94,110.43 58.67,110.7 R238.1
N16248965: length 2.5
  BOTTOM w0.147: U70.1 57.94,109.97 57.4,110.5 R239.1
N16303893: length 2.2
  TOP w0.147: SW3.11 v1(109.3,28.23)
  BOTTOM w0.147: v1(109.3,28.23) R515.1
N16303897: length 2.2
  TOP w0.147: SW3.12 v1(108.03,28.23)
  BOTTOM w0.147: v1(108.03,28.23) R511.1
N16303901: length 2.2
  TOP w0.147: SW3.13 v1(106.76,28.23)
  BOTTOM w0.147: v1(106.76,28.23) R504.1
N16303905: length 2.2
  TOP w0.147: SW3.14 v1(105.49,28.23)
  BOTTOM w0.147: v1(105.49,28.23) R499.1
N16303921: length 2.2
  TOP w0.147: SW3.9 v1(111.84,28.23)
  BOTTOM w0.147: v1(111.84,28.23) R530.1
N16303925: length 2.2
  TOP w0.147: SW3.10 v1(110.57,28.23)
  BOTTOM w0.147: v1(110.57,28.23) R520.1
N16679303: length 4.5
  TOP w0.147: U59.60 157.55,12.62 v1(156.51,11.57)
  TOP w0.203: v1(156.51,11.57) R206.2
  BOTTOM w0.203: v1(156.51,11.57) R206.2
N16679944: length 5
  TOP w0.147: U59.63 158.75,12.77 159.86,11.66 v1(160.32,11.66)
  TOP w0.203: v1(160.32,11.66) R209.2
  BOTTOM w0.203: v1(160.32,11.66) R209.2
N16679981: length 4.1
  TOP w0.147: v1(157.78,11.57) 157.78,12.38 157.95,12.55 U59.61
  TOP w0.203: v1(157.78,11.57) R207.2
  BOTTOM w0.203: v1(157.78,11.57) R207.2
N16680014: length 4.4
  TOP w0.147: v1(159.05,11.66) 158.35,12.35 U59.62
  TOP w0.203: R208.2 v1(159.05,11.66)
  BOTTOM w0.203: v1(159.05,11.66) R208.2
N16753626: length 4.8
  BOTTOM w0.147: R449.2 65.49,37.21 65.02,37.68 65.02,38.12 63.72,39.42 J33.6
N16753680: length 4.3
  BOTTOM w0.147: J33.15 66.22,49.36 65.39,50.2 R409.2
N16754334: length 5.9
  BOTTOM w0.147: R447.2 68.03,37.21 67.15,38.09 66.01,38.09 65.22,38.88 J33.12
N16756061: length 1.5
  TOP w0.147: J25.2 76.32,41.51 76.35,41.48 R685.1
N16814557: length 1.4
  BOTTOM w0.147: U89.5 153,38 R445.2
N16814563: length 2.2
  BOTTOM w0.147: R438.1 154.05,38.64 154.05,39.13 153.76,39.42 U89.4
N16814605: length 2.4
  BOTTOM w0.147: R400.2 133.88,54.26 134.78,53.36 U84.5
N16814611: length 2.2
  BOTTOM w0.147: R406.1 133.1,53.1 133.65,52.56 U84.4
N16814651: length 2
  BOTTOM w0.147: U82.5 141.29,54.43 141.08,54.64 R397.2
N16814659: length 2.4
  BOTTOM w0.147: U82.4 140.62,53.83 140.34,54.12 140.34,54.51 140.22,54.62 R403.1
N16879988: length 2.8
  TOP w0.147: R38.1 94.69,106.84 U13.F9
N16880168: length 7.1
  TOP w0.147: U13.T7 92.4,97.86 92.57,97.7 92.57,97.69 93.4,96.86 95.18,96.86 95.69,96.35 95.69,95.99 95.8,95.89 96.79,95.89 97.03,95.65 TP15.1
N16887346: length 7.4
  TOP w0.147: U23.H5 v1(93.86,82.3)
  BOTTOM w0.114: 98.81,81.1 96.07,81.1 95.86,81.31 95.86,81.34 95.86,81.65 95.86,81.65 95.86,81.67 95.62,81.9 94.45,81.9 94.05,82.3 v1(93.86,82.3)
  BOTTOM w0.147: 98.81,81.1 99.13,80.79 R320.1
N16887377: length 0.6
  TOP w0.147: U23.H3 v1(93.86,83.9)
N16887386: length 0.6
  TOP w0.147: U23.F3 v1(95.46,83.9)
N16887395: length 0.6
  TOP w0.147: U23.E4 v1(96.26,83.1)
N16887404: length 0.6
  TOP w0.147: U23.F5 v1(95.46,82.3)
N16937764: length 1.8
  TOP w0.147: R147.1 86.87,51.9 86.69,51.72 U37.5
N16938293: length 1.5
  BOTTOM w0.147: R506.1 126.82,58.68 126.82,58.68 U98.5
N17211229: length 2.9
  BOTTOM w0.147: J38.33 67.41,15.31 66.9,15.82 R548.2
N17247526: length 2.3
  TOP w0.147: LD16.2 v1(36.35,75.93)
  BOTTOM w0.147: v1(36.35,75.93) R421.2
N17247539: length 2.5
  TOP w0.147: LD17.2 v1(34.32,75.93)
  BOTTOM w0.147: R420.2 34.82,75.3 34.64,75.48 34.64,75.61 v1(34.32,75.93)
N17247599: length 2.3
  TOP w0.147: LD18.2 v1(32.28,75.9)
  BOTTOM w0.147: R419.2 v1(32.28,75.9)
N17247637: length 2.4
  TOP w0.147: LD19.2 v1(30.25,75.95)
  BOTTOM w0.147: R418.2 v1(30.25,75.95)
N17247662: length 2.2
  TOP w0.147: v1(51.99,71.53) 52.12,71.4 LD14.2
  BOTTOM w0.147: v1(51.99,71.53) R381.2
N17247701: length 2.1
  TOP w0.147: LD13.2 50.93,70.69 v1(51,70.61)
  BOTTOM w0.147: R382.2 50.64,70.25 v1(51,70.61)
N17247743: length 2.2
  TOP w0.147: LD12.2 v1(22.66,90.18)
  BOTTOM w0.147: v1(22.66,90.18) 22.66,89.58 22.53,89.45 R383.2
N17247786: length 2.1
  TOP w0.147: v1(19.61,89.04) 19.9,89.33 LD11.2
  BOTTOM w0.147: R384.2 19.75,88.9 v1(19.61,89.04)
N17248427: length 2.9
  TOP w0.147: R413.2 37.02,50.28 36.7,49.97 U34.7
N17248432: length 2.2
  TOP w0.147: R402.2 36.83,40.91 36.7,41.04 U34.10
N17248439: length 2.8
  TOP w0.147: R401.2 33.69,40.81 34.28,41.4 34.91,41.4 35.43,41.93 U34.9
N17546132: length 5.1
  BOTTOM w0.147: R542.2 73.76,15.99 73.28,15.51 71.6,15.51 71.6,15.51 71.22,15.51 70.91,15.2 J38.26
N17546158: length 3.3
  BOTTOM w0.147: J38.28 69.91,15.04 71.42,16.54 R544.2
N17682848: length 2.8
  TOP w0.147: R92.4 129.31,96.26 129.29,96.29 R74.2
N17682861: length 2.8
  TOP w0.147: R73.2 125.73,96.06 125.71,96.04 R92.1
N17683733: length 3.4
  BOTTOM w0.147: R227.3 R215.2
N17683748: length 3.4
  BOTTOM w0.147: R227.2 R216.2
N17685678: length 1.8
  BOTTOM w0.147: R233.1 132.99,113.55 132.72,113.83 R228.2
N17685693: length 1.7
  BOTTOM w0.147: R229.2 130.68,113.93 130.24,113.49 R233.4
N17685736: length 2
  BOTTOM w0.147: R352.2 133.5,66.91 132.84,66.25 R351.1
N17685749: length 2
  BOTTOM w0.147: R350.2 133.5,68.38 132.88,69 R351.4
N17686321: length 1.6
  TOP w0.147: R22.2 88.83,121.46 88.9,121.53 R10.2
N17686333: length 1.4
  TOP w0.147: R22.3 86.08,121.38 86.11,121.4 R11.2
N17786037: length 2.1
  TOP w0.254: U9.2 32.86,118.48 33.15,118.76
N17786049: length 4.7
  TOP w0.254: v1(34.42,116.6) 34.29,116.48 U9.4
  BOTTOM w0.254: v1(34.42,116.6) 33.38,115.57 R231.1 33.38,113.92 33.4,113.9 R232.2
N18116794: length 1.9
  BOTTOM w0.147: R286.2 33.73,95.17 33.47,95.43 Q13.1
N18116818: length 2.1
  BOTTOM w0.147: Q12.1 28.37,113.3 27.69,113.3 27.59,113.39 R230.1
N18116875: length 1.4
  TOP w0.147: R30.1 33.23,112 Q3.1
N18117332: length 1.2
  BOTTOM w0.147: Q14.1 R324.2
N18117389: length 1.4
  BOTTOM w0.147: Q16.1 R343.1
N18275385: length 1.8
  TOP w0.147: U48.6 94.88,31.89 v1(94.64,32.13)
  BOTTOM w0.147: R459.1 v1(94.64,32.13)
N18276744: length 1.5
  TOP w0.147: R190.2 C169.1
N18280417: length 2
  TOP w0.254: U53.4 R195.2
N18280437: length 2.9
  BOTTOM w0.147: U93.4 79.21,25.58 79.67,26.04 R491.2
N18280477: length 2
  TOP w0.254: U52.4 R194.2
N18280857: length 2.2
  BOTTOM w0.147: R492.2 75.06,25.66 74.15,24.75 U94.4
N18289350: length 2.3
  BOTTOM w0.147: U76.5 130.61,93.64 130.73,93.76 131.5,93.76 C277.1
N18321769: length 2.2
  BOTTOM w0.147: U70.31 55.84,107.56 55.23,108.18 R243.1
N18546005:
  vias: v1(167.46,100.48) v1(167.46,99.47) v1(168.48,100.48) v1(168.48,99.47) v1(169.49,101.5) v1(169.49,100.48) v1(169.49,99.47) v1(170.51,101.5) v1(170.51,100.48) v1(170.51,99.47)
N18546027: length 3.8
  TOP w0.381: R64.2 161.56,94.13 160.99,94.13 159.83,92.98 LD5.1
N18546044: length 2.1
  TOP w0.381: D2.1 159.78,96.98 LD5.2
N18867885: length 3.8
  BOTTOM w0.147: U79.21 68.81,73.4 69.5,74.09 70.21,74.09 70.83,74.71 R325.2
N18867903: length 3
  BOTTOM w0.147: R326.2 69.56,74.71 68.31,73.47 U79.20
N18867905: length 2.7
  BOTTOM w0.147: R327.2 68.33,74.15 67.81,73.64 U79.19
N18867915: length 2.6
  BOTTOM w0.147: R328.2 67.06,74.15 67.31,73.89 U79.18
N18867925: length 2.9
  BOTTOM w0.147: R329.2 65.82,74.71 66.81,73.72 U79.17
N18867943: length 3.7
  BOTTOM w0.147: U79.16 66.31,73.65 65.91,74.06 65.21,74.06 64.55,74.71 R330.2
N18867953: length 4.2
  BOTTOM w0.147: R331.2 63.28,74.71 64.34,73.65 65.43,73.65 65.81,73.27 U79.15
N18867955: length 4.8
  BOTTOM w0.147: R332.2 62.01,74.71 63.45,73.27 64.96,73.27 65.31,72.92 U79.14
N18968782: length 1.5
  TOP w0.254: U36.5 R153.2
N18977129: length 5.6
  BOTTOM w0.147: Y3.2 132.02,39.13 C433.1 132.83,39.94 U87.3
N18977189: length 8.9
  BOTTOM w0.147: U87.2 133.4,39.44 133.17,39.21 133.17,35.91 132.93,35.67 C439.1 131.89,35.67 131.55,35.33 Y3.1
N19031494: length 2.4
  TOP w0.254: U9.9 30.87,116.98 v1(30.86,116.98)
  BOTTOM w0.254: v1(30.86,116.98) 30.35,116.98 30.12,117.22 C215.1
N19312123: length 3.3
  BOTTOM w0.147: D7.3 3.94,41.57 3.92,41.58 R428.2 R427.1
N19753713: length 8.5
  TOP w0.254: D5.1 165.45,69.73 166.22,68.96 C116.2 165.57,64.65 165.56,64.66 165.23,64.66 164.85,64.28 U30.11
N19753729: length 7.8
  TOP w0.147: 168.78,68.85 168.78,65.8 168.5,65.51
  TOP w0.305: C116.1 166.03,63.48 U30.10
  TOP w0.508: 168.5,65.51 166.65,63.67 C116.1
N19753760: length 2.7
  TOP w0.254: R111.1 175.73,78.14 175.51,78.35 174.5,78.35 174.39,78.25 R112.1
N19753772: length 18.4
  TOP w0.147: v1(169,63.23) 168.81,63.04 R129.2 167.3,63.04 166.73,62.48 U30.8
  TOP w0.254: 166.89,75.67 v1(166.93,75.71)
  TOP w0.305: U26.4 166.89,75.67
  L08_SIG2 w0.091: v1(166.93,75.71) 167.74,74.89 167.74,64.49 v1(169,63.23)
N19753820: length 23.7
  TOP w0.254: U30.13 v1(163.17,65.5)
  L08_SIG2 w0.091: v1(163.17,65.5) 163.17,76.59 166.75,80.16 169.79,80.16 170.63,79.32 v1(170.71,79.32)
  BOTTOM w0.147: v1(170.71,79.32) 170.71,79.04 170.18,78.51 R317.1
N19753822: length 6.2
  TOP w0.305: U22.4 v1(165.9,77.91)
  BOTTOM w0.147: R321.2 166.57,77.24 v1(165.9,77.91) 166.51,78.51 R317.2
N19753872: length 26.4
  TOP w0.147: v1(166.69,60.06) 166.26,60.48 U30.4
  TOP w0.254: R112.2 172.85,78.23 C85.1 171.74,77.57 v1(171.73,77.56)
  L08_SIG2 w0.091: v1(166.69,60.06) 167.12,60.49 167.12,62.12 166.4,62.85 166.4,76.5 167.34,77.44 171.61,77.44 v1(171.73,77.56)
N19753878: length 27.2
  TOP w0.147: v1(166.69,61.4) 166.26,60.98 U30.5
  TOP w0.254: v1(171.73,79.78) 171.74,79.77 C85.2 172.84,79.21 R109.2
  L08_SIG2 w0.091: v1(171.73,79.78) 171.42,79.48 171.42,78.18 171.02,77.77 167.18,77.77 165.84,76.43 165.84,62.25 v1(166.69,61.4)
N19753964: length 1.2
  TOP w0.147: C125.1 168.17,60.16 168.16,60.14 R141.1
N19754006: length 2.7
  TOP w0.147: C131.1 156.96,57.85 157.48,58.37 157.73,58.37 158.34,58.98 U30.30
N19754159: length 3.4
  TOP w0.305: U30.25 158.28,61.48 158.21,61.56 157.92,61.56
  TOP w0.381: 157.92,61.56 157.24,61.56 156.37,60.69 R695.2
N19754185: length 1.8
  TOP w0.147: U30.1 165.65,58.98 166.44,58.18 C132.1
N19754201: length 3.9
  TOP w0.305: C115.2 157.97,63.48 U30.21
  TOP w0.508: 155.5,64.8 156.35,63.95 C115.2
N19754203: length 8.2
  TOP w0.254: U30.20 158.88,64.28 158.23,64.93 C115.1 157.51,68.73 157.69,68.92 D4.1
N19754223: length 1.5
  TOP w0.147: U30.22 158.24,62.98 158.2,63.02 R130.2
N19754237: length 14.9
  TOP w0.147: U30.23 156.95,62.48 156.67,62.19 v1(156.55,62.19) 156.55,63 R130.1
  TOP w0.305: U24.4 154.58,72.14 v1(156.34,70.39)
  BOTTOM w0.254: v1(156.34,70.39) 156.34,62.92 156.55,62.7 v1(156.55,62.19)
N19754314: length 4.6
  TOP w0.305: v1(154.97,80.65) 155.15,80.47 U21.4
  BOTTOM w0.147: R318.1 155.65,79.97 v1(154.97,80.65) 154.38,80.06 R319.1
N19754320: length 17.8
  TOP w0.254: v1(159.6,65.24) 159.85,65.24 160.18,64.92 U30.19
  L08_SIG2 w0.091: v1(159.6,65.24) 159.23,65.61 159.23,74.45 157.08,76.6 v1(154.81,76.6)
  BOTTOM w0.147: R319.2 154.38,77.02 v1(154.81,76.6)
N19754322: length 18.4
  TOP w0.254: U30.18 160.68,65.31 v1(160.62,65.37)
  L08_SIG2 w0.091: v1(155.83,77.35) 159.26,77.35 161.16,75.44 161.16,65.92 v1(160.62,65.37)
  BOTTOM w0.147: R318.2 155.65,77.52 v1(155.83,77.35)
N19754431: length 3.7
  TOP w0.147: R129.1 167.63,63.88 167.07,63.32 167.07,63.32 166.72,62.98 U30.9
N19754435: length 22.2
  TOP w0.254: U30.12 163.67,65.05 164.12,65.5 v1(164.63,65.5)
  L08_SIG2 w0.091: v1(164.63,65.5) 165.18,66.04 165.18,76.27 167.72,78.81 170.08,78.81 170.69,78.21 v1(170.81,78.21)
  BOTTOM w0.147: v1(170.81,78.21) 170.81,77.75 170.31,77.24 R321.1
N19754522: length 2.9
  TOP w0.254: R119.1 144.75,74.97 144.5,74.71 144.5,74.02
N19754526: length 25.3
  TOP w0.147: v1(157.68,60.96) 157.74,61.02 158.15,61.02 158.19,60.98 U30.26
  TOP w0.254: v1(149.26,75.88) 149.2,75.94 C94.1 147.63,75.94 R113.2
  L08_SIG2 w0.091: v1(157.68,60.96) 157.7,60.97 157.7,73.89 155.7,75.88 v1(149.26,75.88)
N19754534: length 24.8
  TOP w0.147: v1(157.73,60.21) 157.93,60.21 158.2,60.48 U30.27
  TOP w0.254: 148.71,74.97 148.72,74.97 v1(149.26,74.97) ; 148.71,74.97 R119.2 ; 148.71,74.97 C94.2
  L08_SIG2 w0.091: v1(157.73,60.21) 157.25,60.7 157.25,73.24 155.52,74.97 v1(149.26,74.97)
N19754630: length 1.5
  TOP w0.147: U30.32 160.18,57.31 160.07,57.2 C137.2
N19754677: length 1.1
  TOP w0.147: R142.2 154.11,56.14 C136.1
N20142928: length 1.7
  BOTTOM w0.254: U62.2 90.04,127.14 89.64,126.74 C200.1
N20753582: length 2.5
  BOTTOM w0.254: R267.2 R261.2 C248.1
N23484157: length 3.5
  TOP w0.147: v1(55.88,103.52) R53.1
  BOTTOM w0.147: R53.1 v1(55.88,103.52) 56.65,103.52 56.9,103.76 U70.24
N23484680: length 3.2
  TOP w0.147: v1(59.18,102) R59.1
  BOTTOM w0.147: R59.1 v1(59.18,102) 58.94,102.24 U70.22
N24658557: length 2.8
  TOP w0.147: LD20.2 v1(143.38,32.4)
  BOTTOM w0.147: v1(143.38,32.4) 142.48,32.4 142.35,32.53 R462.2
N24754956: length 11.7
  TOP w0.147: v1(36.24,70.96) 36.24,63.62 v1(35.52,62.91)
  BOTTOM w0.147: U80.48 35.68,62.75 v1(35.52,62.91) ; TP69.1 35.35,70.96 v1(36.24,70.96) U80.13
N24775601: length 13.6
  TOP w0.147: TP19.1 34.33,86.37 34.75,85.95 v1(34.75,85.37) 35.33,85.37 35.33,85.37 U20.48 ; U20.13 v1(36.37,77.15)
  BOTTOM w0.147: v1(34.75,85.37) 36.37,83.75 v1(36.37,77.15)
N24776171: length 1.4
  BOTTOM w0.147: R334.2 Q15.1
N24776230: length 1.4
  TOP w0.147: R99.1 10.09,89.43 Q4.1
N24826481: length 4.3
  BOTTOM w0.147: U74.3 173.95,101.48 174.34,101.87 R266.2 R260.1 C245.1
N24972917: length 1.8
  BOTTOM w0.147: R295.3 138.94,94.43 R280.2
N24972919: length 1.8
  BOTTOM w0.147: R295.2 137.41,94.52 R281.2
N24972921: length 6.8
  TOP w0.147: U16.8 137.41,97.02 137.52,96.92 137.81,96.92 137.91,97.02 U16.9 137.91,98.97 v1(137.69,99.2)
  BOTTOM w0.147: R281.1 137.41,96.94 137.69,97.21 C269.2 v1(137.69,99.2)
N24972925: length 4.5
  TOP w0.147: v1(138.68,99.33) 138.41,99.06 U16.10
  BOTTOM w0.147: R280.1 138.94,96.94 138.67,97.21 C269.1 138.67,98.42 138.68,98.44 v1(138.68,99.33)
N24973001: length 1.8
  TOP w0.147: U16.3 R48.1
N25209998: length 1.8
  BOTTOM w0.14: R268.1 73.64,102.68 73.66,102.69 U71.1
N25294505: length 1.6
  TOP w0.254: LD6.2 R80.1
N25395961: length 2.8
  TOP w0.147: U23.A12 99.91,76.3 99.94,76.34 v1(100.4,76.34)
  BOTTOM w0.147: v1(100.4,76.34) 100.4,77.05 100.58,77.23 R323.2
N25526660: length 3
  BOTTOM w0.147: U70.12 63.5,106.56 63.88,106.19 64.24,106.19 64.41,106.02 R254.2
N25657961: length 4.8
  BOTTOM w0.147: R541.2 9.11,17.29 8.43,16.6 6.13,16.6 5.92,16.81 J36.3
N25658118: length 1.8
  BOTTOM w0.147: U99.3 R516.2
N26002209: length 4
  TOP w0.147: R157.2 96.52,45.86 U40.B2
N26002808: length 1.9
  BOTTOM w0.147: Q19.1 94.86,16.66 R552.1
N26002814: length 1.9
  TOP w0.147: LD26.2 R210.1
N26002874: length 2.1
  BOTTOM w0.147: Q18.1 101.89,14.46 102.34,14 R553.1
N26002883: length 1.8
  TOP w0.147: LD23.2 R197.1
N26004018: length 3.4
  TOP w0.254: C49.1 144.78,96.03 144.51,95.75 R82.1 145.34,95.14 145.6,94.88 U17.7
N26004022: length 1.3
  TOP w0.254: R82.2 143.53,95.8 143.51,95.82 C48.2
N26004036: length 12.8
  TOP w0.147: 149.85,93.89 149.83,93.88 ; 150.22,94.17 150.13,94.17
  TOP w0.254: 150.36,93.88 150.37,93.87
  TOP w0.305: 149.85,93.88 150.87,93.88 v1(151,93.74) ; 149.85,93.88 150.19,93.54 ; 149.85,93.88 149.85,93.89 150.13,94.17 ; 149.85,93.88 U17.2
  TOP w0.381: C54.1 v1(142.62,93.87)
  BOTTOM w0.381: v1(142.62,93.87) 145.03,93.87 146.05,92.85 150.11,92.85 v1(151,93.74)
N26004038: length 1.8
  TOP w0.254: C54.2 145.54,93.87 145.55,93.88 U17.9
N26004052: length 2.3
  BOTTOM w0.381: R277.2 R279.1 C272.1
N26016842: length 1.6
  BOTTOM w0.305: U97.9 58.05,19.07 58.04,19.06
N26016868: length 4.2
  BOTTOM w0.147: U97.7 59.05,19.94 59.44,19.55 R535.1 60.79,18.54 60.81,18.56 TP98.1
N26016893: length 1.9
  BOTTOM w0.147: R500.2 58.55,24.04 U97.3
N26118637: length 2.9
  TOP w0.147: U4.1 v1(20.7,121.93)
  BOTTOM w0.147: R221.2 v1(20.7,121.93)
N26118639: length 2.9
  TOP w0.147: U4.4 v1(24.51,121.93)
  BOTTOM w0.147: R220.2 v1(24.51,121.93)
N26120249: length 2.9
  TOP w0.147: U3.1 v1(10.8,121.93)
  BOTTOM w0.147: R223.2 v1(10.8,121.93)
N26120251: length 2.9
  TOP w0.147: U3.4 v1(14.6,121.93)
  BOTTOM w0.147: R222.2 v1(14.6,121.93)
N26140693: length 3.1
  BOTTOM w0.147: R372.2 78.19,59.09 77.54,58.43 76.68,58.43 76.18,57.94 U81.21
N26140695: length 2.3
  BOTTOM w0.147: U81.20 75.68,57.91 76.85,59.09 R373.2
N26140697: length 1.9
  BOTTOM w0.147: R374.2 75.69,58.54 75.18,58.02 U81.19
N26140699: length 1.8
  BOTTOM w0.147: R375.2 74.42,58.54 74.68,58.28 U81.18
N26140701: length 2.2
  BOTTOM w0.147: U81.17 74.18,58.1 73.19,59.09 R376.2
N26140703: length 2.9
  BOTTOM w0.147: U81.16 73.68,58.06 73.21,58.53 72.48,58.53 71.92,59.09 R377.2
N26140705: length 4.1
  BOTTOM w0.147: R378.2 70.61,58.43 70.87,58.18 73.06,58.18 73.18,58.06 U81.15
N26140707: length 4.1
  BOTTOM w0.147: U81.14 72.26,57.37 72.21,57.42 71.12,57.42 69.93,58.61 69.86,58.61 69.38,59.09 R379.2
N26145534: length 1.6
  TOP w0.147: v1(133.75,82.08) 133.85,82.18 Q5.1
  BOTTOM w0.147: v1(133.75,82.08) 133.85,81.99 R312.1
N26145544: length 2.7
  TOP w0.147: v1(133.1,86.23) 133.14,86.28 LD7.2
  BOTTOM w0.147: v1(133.1,86.23) 133.55,86.23 133.6,86.28 R305.1
N26145600: length 1.6
  TOP w0.147: Q2.1 157.8,120.77 157.75,120.72 R20.1
N26145606: length 2.5
  TOP w0.147: LD2.2 v1(156.46,126)
  BOTTOM w0.14: v1(156.46,126) R211.1
N26145666: length 1.5
  TOP w0.147: Q1.1 126.02,121.46 126.09,121.39 R14.1
N26145672: length 1.4
  TOP w0.147: R15.1 121.94,121.2 121.92,121.22 LD3.2
N26145732: length 1.4
  TOP w0.147: Q7.1 9.99,59.09 10.05,59.03 R136.1
N26145738: length 3.8
  TOP w0.147: LD10.2 v1(9.73,62)
  BOTTOM w0.147: R365.1 8.8,61.95 8.84,62 v1(9.73,62)
N26145798: length 1.6
  TOP w0.147: R127.1 133.78,64.77 133.83,64.72 Q6.1
N26145804: length 2.7
  TOP w0.147: v1(138.81,61.72) LD8.2
  BOTTOM w0.147: R360.1 v1(138.81,61.72)
N26145856: length 1.9
  BOTTOM w0.147: R217.1 29.36,121.51 29.27,121.6 Q11.1
N26145862: length 3.5
  TOP w0.147: LD1.2 32.85,126.25 33.27,125.83 v1(33.27,124.98)
  BOTTOM w0.147: R212.1 v1(33.27,124.98)
N26149805: length 1.9
  BOTTOM w0.147: R454.2 106.19,35.4 106.17,35.42 U90.4
N26149864: length 2.5
  BOTTOM w0.147: J30.2 56.13,11.18 56.28,11.32 R555.2
N26219977: length 2.2
  TOP w0.147: SW3.15 v1(104.22,28.23)
  BOTTOM w0.147: v1(104.22,28.23) R490.1
N26220001: length 2.2
  TOP w0.147: SW3.16 v1(102.95,28.23)
  BOTTOM w0.147: v1(102.95,28.23) R475.1
N26314477: length 3.9
  BOTTOM w0.254: R298.2 109.41,97.26 C285.1 109.41,94.66 C279.1 C278.1
N26314562: length 4.1
  BOTTOM w0.381: C291.1 C292.1 116.32,80.66 C296.1 116.4,79.37 116.4,78 R307.2
N26442461: length 2.4
  TOP w0.147: U51.5 R185.1
N26454965: length 1.7
  TOP w0.147: R171.1 141.9,44.14 141.85,44.09 U41.4
N26523524: length 2.3
  TOP w0.147: U40.A5 101.47,45.58 101.75,45.86 R158.1
N26648730: length 2.7
  BOTTOM w0.147: U91.19 54.49,36.45 53.09,37.86 TP90.1
N26648748: length 2.6
  BOTTOM w0.147: U91.20 54.99,36.71 54.22,37.49 54.22,37.98 TP88.1
N26648766: length 3.9
  BOTTOM w0.147: TP87.1 54.38,38.63 54.38,38.52 55.5,37.41 U91.21
N26648784: length 2.7
  BOTTOM w0.147: TP86.1 56,37.76 U91.22
N26648802: length 2.2
  BOTTOM w0.147: U91.23 56.5,37.71 TP89.1
N26648820: length 2.1
  BOTTOM w0.147: TP91.1 57.28,37.1 57.17,37.1 57,36.92 U91.24
N26733190: length 4.7
  TOP w0.254: U32.4 17.78,60.08 v1(17.65,59.96)
  BOTTOM w0.254: v1(17.65,59.96) 18.69,60.99 R364.1 18.69,62.64 18.67,62.66 R361.2
N26733205: length 2.8
  TOP w0.254: U32.2 19.21,58.08 18.53,57.4 18.41,57.4
N26733231: length 2.4
  TOP w0.254: v1(21.21,59.58) 21.2,59.58 U32.9
  BOTTOM w0.254: C402.1 21.95,59.34 21.72,59.58 v1(21.21,59.58)
N26735382: length 2.4
  TOP w0.254: v1(97.16,117.46) 97.16,117.46 U5.9
  BOTTOM w0.254: C202.1 96.92,116.72 97.16,116.95 v1(97.16,117.46)
N26735416: length 3.6
  TOP w0.254: U5.4 97.66,120.89 v1(97.54,121.02)
  BOTTOM w0.254: R213.1 98.31,120.75 98.04,121.02 v1(97.54,121.02) 97.63,121.11 R214.2
N26735457: length 2.1
  TOP w0.254: 95.38,119.75 95.66,119.46 U5.2
N26735496: length 5.4
  BOTTOM w0.254: U65.6 138.6,119.39 138.56,119.44
N26735653: length 3.5
  TOP w0.254: U33.2 133.5,57.04 R145.1 132.18,56.51 132.09,56.42 R144.2
N26736579: length 6.5
  TOP w0.254: U25.6 130.8,76.1 129.22,74.52 127.53,74.52
N26736751: length 1.9
  TOP w0.254: R57.2 154.43,103.73 155.11,104.4 U12.1
N26736805: length 2.7
  TOP w0.254: U12.7 155.76,107.26 v1(155.96,107.46)
  BOTTOM w0.147: R44.2 155.27,107.13 155.6,107.46 v1(155.96,107.46) 156.65,107.46 R49.1
N26881621: length 2.9
  TOP w0.147: v1(138.3,30.24) 138.08,30.46 LD21.1
  BOTTOM w0.147: R464.2 137.07,30.89 137.72,30.24 v1(138.3,30.24)
N27030520: length 2.1
  BOTTOM w0.147: R252.1 70.23,105.79 70.25,105.81 U71.3
N27215594: length 29.8
  TOP w0.147: R76.2 v1(29.44,96.7)
  L08_SIG2 w0.091: v1(29.44,96.7) 25.35,96.7 21.89,93.24 14.45,93.24 13.16,91.95 6.45,91.95 4.52,93.88 J14.11
N27217693: length 4.2
  BOTTOM w0.147: FB19.2 23.1,72.18 23.01,72.09 J21.B9
N27218087: length 5.1
  BOTTOM w0.147: R347.2 6.03,76.93 7.55,75.4 9.07,75.4 9.92,74.54 J21.B12
N27219244: length 4.4
  BOTTOM w0.147: FB14.2 25.41,78.27 24.96,78.71 23.03,78.71 23.01,78.69 J21.A9
N27219552: length 2.2
  BOTTOM w0.147: R336.2 7.61,74.85 J21.A12
N27838027: length 1.8
  TOP w0.147: R24.1 126.23,118.74 U10.6
N27914276: length 2.8
  TOP w0.254: U30.40 164.17,57.47 164.39,57.25 165.43,57.25 165.65,57.03 R577.2
N27928121: length 2
  TOP w0.147: U30.31 159.68,57.43 158.81,56.56 R578.1
N27928168: length 6.6
  TOP w0.254: U17.8 145.28,94.38 145.17,94.49 142.95,94.49 142.52,94.91 142.52,95.22 142.01,95.73 R602.2 R579.1
N27943339: length 1.3
  BOTTOM w0.254: U65.1 146.42,120.14 R580.1
N27943633: length 1.7
  TOP w0.254: v1(96.52,120.76) 96.66,120.62 U5.6
  BOTTOM w0.147: R581.1 v1(96.52,120.76)
N27943804: length 1.5
  BOTTOM w0.254: R582.1 143.78,102.87 143.24,102.33 U72.3
N27943890: length 2.5
  TOP w0.147: R583.1 138.04,55.39 137.04,56.39 U33.4
N27943939: length 2.7
  TOP w0.147: R697.1 135.9,73.92 135.89,73.93 R584.1
  TOP w0.254: U25.1 134.83,75.1 135.19,74.74 135.19,74.74 135.27,74.66 R584.1
N27944274: length 1.6
  TOP w0.254: U9.6 34.02,117.48 v1(34.16,117.62)
  BOTTOM w0.254: v1(34.16,117.62) 33.77,117.22 R585.1
N27944496: length 1.2
  BOTTOM w0.254: R586.1 U62.4
N27944776: length 1.7
  TOP w0.254: v1(17.91,58.94) 18.05,59.08 U32.6
  BOTTOM w0.254: v1(17.91,58.94) 18.57,58.94 R587.1
N27944822: length 1.2
  BOTTOM w0.147: U77.3 47.17,94.84 R588.1
N27945052: length 1.2
  BOTTOM w0.254: U100.3 14.14,18.86 R589.1
N27977097: length 4.7
  TOP w0.147: Y1.1 99.38,56.21 99.21,56.38 99.21,58.1 99.32,58.21 99.33,58.21 99.44,58.32 C133.2 99.44,59.2 99.19,59.45 R138.1
N27977103: length 2.4
  TOP w0.147: R139.1 101.75,59.67 C134.2 101.75,58.35 Y1.3
N28035755: length 3.8
  TOP w0.147: v1(89.15,66.04) 89.15,66.67 89.35,66.87 89.35,68.51 89.46,68.62 U23.N21
  BOTTOM w0.147: R591.2 v1(89.15,66.04)
N28118242: length 2.7
  TOP w0.147: LD7.1 136.23,84.5 136.02,84.28 Q5.3
N28118245: length 2.6
  TOP w0.147: LD2.1 159.55,124.66 158.75,123.86 Q2.3
N28118248: length 2.3
  TOP w0.147: Q1.3 123.8,123.2 123.01,124 LD3.1
N28118251: length 3.3
  TOP w0.381: Q7.3 7.2,61.52 7.63,61.95 LD10.1
N28118254: length 2.9
  TOP w0.147: Q6.3 136.81,64.44 137.32,64.95 LD8.1
N28118257: length 3.2
  TOP w0.147: LD1.1 28.9,126.25 28.78,126.38 v1(28.32,126.38)
  BOTTOM w0.147: Q11.3 v1(28.32,126.38)
N28118260: length 7.2
  TOP w0.254: LD4.2 v1(151.26,103.01)
  BOTTOM w0.254: R276.2 151.51,98.06 151.26,98.31 v1(151.26,103.01)
N28118377: length 2.8
  TOP w0.147: LD9.2 172.71,63.68 v1(172.71,64.91)
  BOTTOM w0.147: v1(172.71,64.91) 172.19,64.39 R362.2
N28118380: length 2.8
  TOP w0.147: v1(163.83,52.21) LD15.2
  BOTTOM w0.147: v1(163.83,52.21) 163.07,52.97 R407.2
N28118607: length 2.8
  TOP w0.147: LD25.2 v1(18.8,10.68)
  BOTTOM w0.14: R556.2 v1(18.8,10.68)
N28118686: length 1.2
  TOP w0.381: R201.2 LD24.2
N28119618: length 2.6
  TOP w0.147: v1(100.82,16.76) 101.33,16.76 101.8,17.24 LD23.1
  BOTTOM w0.147: Q18.3 100.62,16.56 v1(100.82,16.76)
N28119621: length 3.2
  TOP w0.147: v1(95.91,13.27) 95.38,12.73 LD26.1
  BOTTOM w0.147: v1(95.91,13.27) Q19.3
N28789368: length 2.8
  TOP w0.147: TP101.1 50.47,33.17 50.7,32.94 v1(51.82,32.94)
  BOTTOM w0.147: U91.12 51.84,32.91 v1(51.82,32.94)
N28853998: length 1.4
  TOP w0.147: Q20.1 16.49,89.05 R614.1
N28854850: length 3.5
  BOTTOM w0.147: Q21.1 13.38,86.55 14,87.17 R617.1
N28887698: length 11.1
  BOTTOM w0.147: R624.1 76.12,75.61 75.51,75 75.51,73.66 75.77,73.41 75.77,72.29 75.29,71.81 75.29,70.41 75.64,70.05 R625.1 76.19,70.05 77.11,69.14 78.74,69.14 79.22,68.66 R632.1
N28906258: length 2.2
  TOP w0.147: R631.2 J40.2
N28906289: length 2.2
  TOP w0.147: R630.2 J39.2
N29283187: length 5.6
  TOP w0.147: FB26.2 J14.2
N29427242: length 2.6
  TOP w0.147: R696.2 119.77,104.94 120.22,105.38 U103.4
N29650235: length 1.6
  TOP w0.147: U23.A19 v1(99.65,70.7)
  BOTTOM w0.147: v1(99.65,70.7) 100.01,70.34 R345.1
N248107881: length 1.5
  TOP w0.147: R189.2 C168.1

## Copper pours and planes (outline as drawn)
DGND on TOP: outline of 123 points within 1.02,8.02 176.78,132.98 ; 57 cut-outs
DGND on TOP: 115.19,84.2 115.19,62.87 126.26,62.87 126.26,84.2 ; 4 cut-outs
DGND on TOP: 71.48,79.32 74.17,79.32 74.19,79.3 75.62,79.3 75.97,79.65 77.14,79.65 78.59,78.21 78.59,78.18 79.3,77.47 81.58,77.47 81.64,77.42 81.64,76.99 81.23,76.58 76.17,76.58 75.95,76.81 75.95,77.55 75.77,77.72 72.54,77.72 71.48,78.79
DGND on TOP: 140.61,88.7 140.61,132.97 176.78,132.97 176.78,88.7 171.09,88.7 170.99,88.6 170.99,81.1 167.06,81.1 167.06,78.1 165.84,76.88 164.29,76.88 164.29,84.38 157.89,84.38 157.89,76.88 155.56,76.88 154.81,77.62 154.81,81.14 151.23,81.14 151.23,77.44 150.16,76.38 146.96,76.38 146.96,88.49 146.76,88.7
DGND on TOP: 106.86,33.1 115.32,33.1 115.24,33.17 115.24,40.72 112.6,43.36 112.6,46.81 111.81,46.81 109.07,44.07 109.07,38.79 106.53,36.25 106.53,33.43
DGND on TOP: 130.63,49.12 130.63,70.41 148.13,70.41 148.13,61.21 143.33,56.41 137.92,56.41 ; 1 cut-out
DGND on TOP: 132.31,88.19 132.31,84.4 131.8,83.9 131.8,82.98 131.27,82.45 131.27,81.69 130.81,81.23 130.81,76.71 131.11,76.4 133.53,76.4 133.93,76 136.65,76 136.65,79.58 138.05,79.58 138.05,88.19
DGND on TOP: 104.34,68.17 104.34,69.11 102.21,69.11 102.21,76.07 103.58,76.07 103.58,78.44 110.85,78.44 110.85,75.23 106.05,75.23 106.05,69.7 109.02,69.7 109.02,68.17 ; 1 cut-out
DGND on TOP: 63.12,33.68 63.12,44.75 76.25,44.75 76.35,44.86 76.35,46.2 85.55,46.2 86.03,45.72 86.03,44.75 86.28,44.75 86.28,33.68 ; 2 cut-outs
DGND on TOP: 94.31,50.8 97.79,50.8 98.17,50.42 98.17,48.51 100.97,45.72 106.55,45.72 106.55,46.05 113.16,52.65 116.23,52.65 117.73,54.15 126.64,54.15 127.25,53.54 127.25,47.73 126.82,47.29 123.6,47.29 122.28,48.62 112.5,48.62 108.53,44.65 108.53,39.78 102.51,33.76 93.37,33.76 90.63,31.01 90.37,31.01 90.02,31.37 89.15,31.37 86.77,33.76 86.77,41.81 91.62,46.66 93.07,46.66 94.31,47.9 ; 10 cut-outs
DGND on TOP: 97.33,63.96 97.33,54.79 125.6,54.79 125.6,63.96 ; 5 cut-outs
DGND on BOTTOM: 48.67,56.52 48.67,51.13 50.77,51.13 50.77,53.31 50.8,53.34 52.32,53.34 52.37,53.39 52.37,56.52
DGND on BOTTOM: 14.61,23.93 14.61,21.62 17.88,21.62 17.88,23.93
DGND on BOTTOM: 78.99,120.45 78.99,117.17 80.75,117.17 80.75,120.45
DGND on BOTTOM: 53.31,26.54 53.31,21.77 56.08,21.77 56.08,26.54
DGND on BOTTOM: 142.82,106.3 142.82,103.99 144.93,103.99 144.93,106.3
DGND on BOTTOM: 83.9,12.52 83.9,8.74 87.1,8.74 87.1,12.52
DGND on BOTTOM: 78.26,97.87 81.31,97.87 81.31,107.95 79.98,107.95 79.98,110.41 79.86,110.54 76.76,110.54 78.26,109.04
DGND on BOTTOM: 29.11,116.54 29.11,115.37 29.69,114.78 29.69,113.41 32.79,113.41 32.79,116.54
DGND on BOTTOM: 43.79,97.08 43.79,94.56 45.77,94.56 45.77,97.08
DGND on BOTTOM: 140.41,99.64 142.88,99.64 143.31,99.21 145.97,99.21 146.02,99.26 146.02,102.18 148.11,102.18 148.23,102.06 148.23,97.56 147.35,96.67 140.94,96.67 140.36,97.26 140.36,99.59
DGND on BOTTOM: 97.92,119.38 97.92,116.74 97.62,116.44 97.62,115.21 100.76,115.21 100.76,119.38
DGND on BOTTOM: 44.65,91.87 44.65,90.32 46.84,90.32 46.84,91.87
DGND on BOTTOM: 169.85,108.8 169.85,105.79 176.71,105.79 176.71,108.8
DGND on BOTTOM: 59.82,12.52 59.82,8.74 63.27,8.74 63.27,12.52
DGND on BOTTOM: 142.9,113.48 142.9,116.99 141.43,116.99 141.43,119.1 144.83,119.1 144.83,118.34 144.63,118.14 144.63,113.48
DGND on BOTTOM: 79.2,18.08 79.2,15.27 81.92,15.27 81.92,18.08
DGND on BOTTOM: 76.73,79.81 76.73,75.09 79.45,75.09 79.45,79.81
DGND on BOTTOM: 23.37,59.96 19.56,59.96 19.43,60.09 19.43,63.01 23.5,63.01 23.5,60.09
DGND on BOTTOM: 92.11,132.69 92.11,130.3 94.67,130.3 94.67,132.69
DGND on BOTTOM: 92.2,127.43 92.2,125.58 93.83,125.58 93.83,127.43
DGND on BOTTOM: 73.25,115.01 73.25,112.57 75.49,112.57 75.49,115.01
DGND on L02_GND1: 1.02,8.02 1.02,47.69 1.02,47.69 1.02,50.41 1.68,50.41 2.54,50.77 2.9,51.63 2.9,52.08 2.54,52.94 1.68,53.29 1.02,53.29 1.02,55.16 1.68,55.16 2.54,55.52 2.9,56.38 2.9,56.83 2.54,57.69 1.68,58.04 1.02,58.04 1.02,60.87 1.02,60.87 1.02,132.98 9.02,132.98 9.02,130.95 9.27,130.7 10.89,130.7 12.32,129.27 12.32,128.54 11.68,127.9 11.68,124.98 13.72,124.98 13.72,128.02 13.08,128.65 13.08,129.29 14.36,130.57 15.88,130.57 16.51,131.21 16.51,132.98 18.67,132.98 18.67,130.57 20.95,130.57 22.23,129.3 22.23,128.79 21.59,128.16 21.59,124.98 23.62,124.98 23.62,128.41 26.92,131.71 26.92,132.98 176.78,132.98 176.78,8.02 ; 7 cut-outs
DGND on L04_GND2: 1.02,8.02 1.02,47.31 1.02,47.31 1.02,50.41 1.68,50.41 2.54,50.77 2.9,51.63 2.9,52.08 2.54,52.94 1.68,53.29 1.02,53.29 1.02,55.16 1.68,55.16 2.54,55.52 2.9,56.38 2.9,56.83 2.54,57.69 1.68,58.04 1.02,58.04 1.02,60.52 1.02,60.52 1.02,132.98 176.78,132.98 176.78,8.02 ; 6 cut-outs
DGND on L07_GND3: 1.02,8.02 1.02,46.95 1.02,46.95 1.02,50.41 1.68,50.41 2.54,50.77 2.9,51.63 2.9,52.08 2.54,52.94 1.68,53.29 1.02,53.29 1.02,55.16 1.68,55.16 2.54,55.52 2.9,56.38 2.9,56.83 2.54,57.69 1.68,58.04 1.02,58.04 1.02,60.39 1.02,60.39 1.02,132.98 176.78,132.98 176.78,8.02 ; 6 cut-outs
DGND on L09_GND4: 1.02,8.02 1.02,49.01 1.02,49.01 1.02,50.41 1.68,50.41 2.54,50.77 2.9,51.63 2.9,52.08 2.54,52.94 1.68,53.29 1.02,53.29 1.02,55.16 1.68,55.16 2.54,55.52 2.9,56.38 2.9,56.83 2.54,57.69 1.68,58.04 1.02,58.04 1.02,60.34 1.02,60.34 1.02,132.98 176.78,132.98 176.78,8.02 ; 6 cut-outs
GNDUSB on TOP: 168.23,35.45 168.23,38.94 174.69,38.94 174.94,39.2 174.94,42.18 174.69,42.43 173.04,42.43 173.04,46.5 177.35,46.5 177.35,35.45
VCC1V2_DDR on TOP: 98,119.81 98,126.22 101.85,126.22 101.85,119.81
VCC1V2_DDR on TOP: 87.36,115.06 87.36,119.63 92.46,119.63 92.46,115.06
VCC1V2_DDR on BOTTOM: 87.88,119.78 92.99,119.78 92.99,115.08 87.88,115.08
VCC1V2_DDR on L08_SIG2: 87.76,115.57 93.85,115.57 93.85,118.75 94.87,119.76 102.23,119.76 102.23,124.01 93.53,124.01 87.76,118.24
VCC1V8 on TOP: 46.36,63.13 46.36,61.28 47.48,60.15 48.75,60.15 48.75,63.13
VCC1V8 on TOP: 132.08,116.02 139.56,116.02 139.56,107.34 132.08,107.34
VCC1V8 on TOP: 113.06,46.85 113.06,45.61 121.74,45.61 121.74,46.85
VCC1V8 on TOP: 53.99,64.35 53.99,61.93 56.13,61.93 56.13,64.35
VCC1V8 on TOP: 95.85,37.99 95.85,36.29 102.11,36.29 102.11,37.99
VCC1V8 on BOTTOM: 132.08,107.34 132.08,112.03 134.49,112.03 134.49,116.62 139.59,116.62 139.88,116.33 142.37,116.33 142.37,110.12 139.59,107.35 137.19,107.35 137.19,107.34
VCC1V8 on L03_SIG1: 49.23,65.38 54.46,65.38 56.67,63.17 56.67,60.88 55.85,60.07 48.41,60.07 47.78,60.71 47.78,63.93
VCC1V8 on L06_PWR2: 127.52,36.52 118.45,27.45 94.61,27.45 90.42,31.64 90.42,49.8 90.55,49.93 119.28,49.93 133.74,64.38 137.28,64.38 147.57,74.68 147.57,92.01 131.95,107.63 131.95,110.18 130.11,112.03 126.55,112.03 122.98,115.6 95.78,115.6 91.52,119.86 75.55,119.86 74.11,118.42 74.11,95.19 67.96,95.19 67.96,109.22 61.85,109.22 61.85,111.84 67.87,111.84 67.96,111.93 67.96,122.07 70.46,124.57 81.14,124.57 82.51,123.2 84.74,123.2 86.11,124.57 95.63,124.57 98.44,121.77 129.96,121.77 131.55,120.18 145.6,120.18 156.46,109.32 156.46,65.46 144.82,53.81 137.79,53.81 137.79,50.81 136.91,49.93 135.89,49.93 134.62,51.2 132.46,51.2 127.52,46.25
VCC1V8_HSE on TOP: 74.24,124.81 70.61,124.81 70.61,122.44 74.55,122.44 74.55,124.5
VCC1V8_HSE on BOTTOM: 70.36,122.44 70.36,129.14 71.91,130.7 74.55,130.7 74.55,125.11 74.55,125.11 74.55,123.46 73.53,122.44
VCC3V3_IO_HSE on TOP: 38.69,121.76 38.69,124.02 38.39,124.32 37.94,124.32 37.88,124.37 37.88,126 41.53,126 41.53,121.76
VCC3V3_IO_HSE on BOTTOM: 38.44,124.98 38.44,120.42 41.27,120.42 41.27,124.98
VCC3V3_PREREG on TOP: 97.28,119.11 95.24,119.11 94.11,117.98 94.11,115.25 97.13,115.25 97.13,117.61 96.9,117.84 96.9,118.6 97.03,118.73 97.28,118.73
VCC3V3_PREREG on TOP: 136.6,57.5 136.6,59.79 139.51,59.79 139.51,57.84 139.17,57.5
VCC3V3_PREREG on TOP: 149.79,96.95 158.01,96.95 158.01,101.94 149.32,101.94 149.32,97.42
VCC3V3_PREREG on TOP: 131.09,75.72 132.86,75.72 132.86,73.31 134.01,73.31 134.01,71.18 131.09,71.18
VCC3V3_PREREG on TOP: 156.19,102.38 156.19,104.79 159.26,104.79 159.64,104.41 159.64,102.76 159.26,102.38
VCC3V3_PREREG on BOTTOM: 144.91,122.82 141.22,122.82 141.22,119.9 141.48,119.65 144.78,119.65 144.91,119.78
VCC3V3_PREREG on BOTTOM: 142.11,102.5 141.6,102.5 140.39,101.28 140.39,100.05 142.73,100.05 142.73,101.88
VCC3V3_PREREG on L05_PWR1: 132.73,56.64 131.95,57.42 131.95,66.57 135.62,66.57 136.5,67.45 136.5,70.9 136.14,71.26 131.17,71.26 128.6,73.83 128.6,94.22 129.79,95.41 134.72,95.41 143.26,103.95 143.26,113.3 135.76,120.79 98.04,120.79 97.93,120.91 97.93,115.33 97.16,114.55 93.34,114.55 92.84,115.06 92.84,121.93 98.3,127.4 141,127.4 160.53,107.87 160.53,101.97 151,92.45 139.76,92.45 136.84,89.53 136.84,81.49 143.25,75.08 143.25,66.93 140.84,64.53 140.84,57.29 140.19,56.64 ; 1 cut-out
VCC3V3_TA on TOP: 72.39,21.1 72.39,16.77 75.16,14 84.09,14 84.71,14.62 84.71,17.92 84.45,18.18 77.95,18.18 75.03,21.1
VCC3V3_TA on BOTTOM: 82.27,17.82 82.27,13.17 84.96,13.17 84.96,17.41 84.56,17.82
VCC3V3_TA on BOTTOM: 66.52,20.87 66.52,19.65 72.95,19.65 72.95,20.87
VCC3V3_TA on BOTTOM: 57.66,21.1 50.14,21.1 50.14,13.6 55.37,13.6 55.37,18.3 56.82,19.75 57.51,19.75 57.66,19.89
VCC3V3_TA on L05_PWR1: 50.51,14.4 50.51,16.65 57.24,23.38 66.42,23.38 68.33,21.48 68.33,18.3 63.88,13.86 51.05,13.86
VCC3V3_TA on L06_PWR2: 64.01,21.86 64.01,51.37 69.72,57.09 69.72,65.04 70.62,65.94 72.26,65.94 73.15,65.04 73.15,61.36 73.77,60.73 79.97,60.73 86.71,53.99 109.73,53.99 109.98,53.74 109.98,42.56 112.19,40.35 112.19,38.4 111.65,37.86 104.9,37.86 103.98,38.78 103.98,40.25 106.17,42.43 106.17,50.13 105.49,50.81 73.7,50.81 72.71,49.82 72.71,26.11 74.55,24.27 96.9,24.27 98.55,22.62 98.55,18.94 66.93,18.94
VCC3V3_XDS on TOP: 167.39,11.44 167.39,10.56 167.26,10.43 163.58,10.43 163.58,12.08 164.72,12.08 165.35,11.44
VCC3V3_XDS on L05_PWR1: 139.04,23.76 133.48,23.76 131.95,25.29 131.95,28.84 135.64,32.53 154.56,32.53 159.51,27.57 162.69,27.57 165.93,24.33 165.93,10.29 163.91,8.27 150.61,8.27 140.46,18.42 140.46,22.34
VCC3V3_XDS on L08_SIG2: 140.51,17.04 125.96,31.6 125.96,46.13 122.89,49.2 122.89,56.16 136.63,56.16 138.86,53.92 138.86,39.12 142.85,35.13 153.82,35.13 158.24,30.71 158.24,22.38 152.91,17.04
VCC_1V8_FT4232 on TOP: 132.24,46.75 132.24,37.83 135.13,34.94 146.43,34.94 149.35,37.86 149.35,45.35 148.84,45.86 146.43,45.86 144.15,43.58 144.15,41.13 142.12,39.11 135.8,39.11 134.49,40.42 134.49,46.24 133.99,46.75
VCC_3V3_FT4232 on L06_PWR2: 128.27,46.75 134.37,52.85 144.4,52.85 144.4,48.91 143.51,48.02 138.94,48.02 134.24,43.32 134.24,37.35 135.38,36.21 145.67,36.21 147.45,37.99 147.45,43.58 156.21,43.58 156.21,41.04 147.4,32.23 141.74,32.23 136.7,27.19 128.4,27.19 125.48,30.11 125.48,33.15 128.27,35.94
VCC_3V3_MIPI on BOTTOM: 58.55,53.48 58.55,52.16 61.85,52.16 61.85,53.48
VCC_3V3_MIPI on L08_SIG2: 59.69,52.21 59.69,53.23 62.1,53.23 62.1,52.21
VCC_3V3_SYS on TOP: 32.51,116.85 32.51,118.25 31.74,119.02 28.65,119.02 28.65,117.01 31.02,117.01 31.24,117.24 32,117.24 32.13,117.11 32.13,116.85
VCC_3V3_SYS on TOP: 20.75,45.99 20.75,43.7 26.04,43.7 26.04,45.99
VCC_3V3_SYS on TOP: 19.56,59.7 19.56,58.31 20.33,57.54 23.42,57.54 23.42,59.63 21.14,59.63 20.83,59.32 20.07,59.32 19.94,59.45 19.94,59.7
VCC_3V3_SYS on TOP: 119.75,62.53 119.95,62.33 119.95,60.85 114.71,60.85 114.71,61.75 116.1,61.75 116.89,62.53
VCC_3V3_SYS on TOP: 138.55,88.15 138.56,88.15 138.56,93.02 142.04,93.02 142.04,88.79 146.25,88.79 146.25,77.42 138.98,77.42 138.55,77.85
VCC_3V3_SYS on BOTTOM: 75.82,112.22 76.71,112.22 76.71,115.46 75.82,115.46
VCC_3V3_SYS on BOTTOM: 74.82,120.4 76.21,120.4 77.09,119.52 77.09,116.94 76.71,116.94 76.71,118.38 76.26,118.83 74.82,118.83
VCC_3V3_SYS on BOTTOM: 91.72,129.74 91.72,132.65 90.42,132.65 90.42,129.74
VCC_3V3_SYS on BOTTOM: 138.56,93.28 141.55,93.28 143.62,91.21 145.37,91.21 145.37,80.54 138.55,80.54 138.55,88.15 138.56,88.15
VCC_3V3_SYS on BOTTOM: 43.58,45.35 43.58,46.88 52.84,46.88 52.84,45.35
VCC_3V3_SYS on BOTTOM: 15.75,18.68 16.26,18.68 17.48,19.9 17.48,21.21 15.24,21.21 14.99,20.96 14.99,19.45
VCC_3V3_SYS on BOTTOM: 48.5,92.8 47.31,92.8 47.31,90.57 47.56,90.31 48.96,90.31 49.38,90.73 49.38,91.92
VCC_3V3_SYS on L05_PWR1: 1.35,53.3 1.02,53.3 1.02,55.16 1.68,55.16 2.54,55.52 2.9,56.38 2.9,56.83 2.54,57.69 1.68,58.04 1.02,58.04 1.27,59.12 1.27,132.98 175.81,132.98 175.81,8.02 1.27,8.02 1.27,47.79 1.06,47.79 1.06,50.41 1.44,50.41 1.83,50.41 2.64,50.78 2.9,51.63 2.9,52.08 2.54,52.94 1.68,53.29 ; 7 cut-outs
VCC_3V3_SYS on L06_PWR2: 1.27,8.02 1.27,132.98 177.04,132.98 177.04,8.02 ; 38 cut-outs
VCC_5V0 on TOP: 81.72,125.48 81.72,122.4 84.79,122.4 84.79,125.48
VCC_5V0 on TOP: 34.87,48.53 33.48,48.53 33.1,48.91 33.1,51.32 33.22,51.45 34.75,51.45 35.13,51.07 35.13,48.78
VCC_5V0 on TOP: 171.63,87.52 171.63,79.83 176.73,79.83 176.73,88.14 172.26,88.14
VCC_5V0 on BOTTOM: 171.63,87.52 171.63,79.83 176.78,79.83 176.78,88.14 172.26,88.14
VCC_5V0 on L03_SIG1: 24.26,118.38 24.26,116.47 26.29,116.47 26.29,118.38
VCC_5V0 on L03_SIG1: 33.81,49.47 33.81,51.25 35.2,51.25 35.2,49.47
VCC_5V0 on L06_PWR2: 173.01,81.29 173.01,106 158.08,120.93 132.07,120.93 130.65,122.35 98.78,122.35 95.88,125.24 85.96,125.24 84.42,123.7 82.65,123.7 81.11,125.24 34.04,125.24 28.32,119.52 28.32,112.92 16.64,112.92 16.64,126.75 22.87,132.98 174.75,132.98 176.71,131.02 176.71,81.29
VCC_5V0_HSE on TOP: 70.75,126.07 70.75,125.11 74.29,125.11 74.8,124.6 80.64,124.6 80.9,124.86 80.9,127.01 79.5,128.41 75.56,128.41 74.53,127.38 74.53,126.22 74.38,126.07
VCC_CORE on TOP: 124.16,77.54 124.16,83.58 127.41,83.58 128.05,84.21 128.05,91.99 131.97,91.99 131.97,84.71 131.32,84.05 131.32,83.26 130.81,82.75 130.81,81.89 130.32,81.41 130.32,77.54
VCC_LM5140 on TOP: 159.51,71.4 159.51,69.98 163.65,69.98 163.65,71.4
VDD1V8_CLKBUF on TOP: 61.47,111.99 61.47,109.58 57.66,109.58 57.66,111.99
VDD1V8_CLKBUF on L03_SIG1: 57.84,102.29 61.6,102.29 61.72,102.41 61.72,111.35 58.01,111.35 58.01,103.07 57.84,102.9
VDD3V3_CLKBUF on L05_PWR1: 52.83,105.55 52.83,109.36 54.48,111.01 67.31,111.01 67.65,110.67 67.65,109.02 68.58,108.09 73.91,108.09 75.56,106.44 75.56,103.52 74.8,102.76 68.71,102.76 67.82,101.87 67.82,95.39 65.66,93.23 62.87,93.23 59.69,96.41 59.69,99.46 54.74,104.41 53.98,104.41
VDD_0V85 on TOP: 154.55,106.31 153.53,107.33 150.63,107.33 150.63,109.21 150.63,109.21 150.63,114.31 155.45,114.31 155.45,106.44 155.32,106.31
VDD_0V85 on BOTTOM: 155.32,116.34 155.32,107.57 150.79,107.57 150.79,116.34
VDD_1V0 on BOTTOM: 44.34,92.44 45.17,92.44 45.17,94.17 41.2,94.17 40.89,93.87 40.89,91.58 41.15,91.33 43.23,91.33
VDD_1V0 on L05_PWR1: 34.04,101.61 34.04,104.28 36.7,106.95 39.51,106.95 39.72,106.74 39.72,104.95 42.67,102 48.64,102 49.15,101.49 49.15,99.71 48.78,99.34 44.2,99.34 43.91,99.05 43.91,91.93 43.31,91.33 41.36,91.33 41.01,91.69 41.01,93.15 41.82,93.96 41.82,97.01 38.73,100.09 35.56,100.09
VDD_1V1 on TOP: 18.86,59.9 12.45,59.9 12.45,65.28 18.86,65.28
VDD_1V1 on L06_PWR2: 13.08,66.31 13.08,59.58 15.75,56.91 43.78,56.91 49.55,62.68 49.55,86.53 47.76,88.31 40.99,88.31 35.24,82.56 34.54,82.56 34.54,81.68 35.81,81.68 35.81,66.44 34.29,66.44 34.29,65.42 35.69,65.42 35.69,62.5 29.28,62.5 25.47,66.31
VDD_2V5 on TOP: 33.21,116.14 39.62,116.14 39.62,111.09 33.21,111.09
VDD_2V5 on L06_PWR2: 29.46,63.26 35.17,63.26 35.17,64.54 34.92,64.78 33.4,64.78 33.27,64.91 33.27,66.94 33.53,67.2 34.92,67.2 35.17,67.44 35.17,80.62 34.87,80.91 33.66,80.91 33.4,81.17 33.4,83.2 33.53,83.33 34.92,83.33 35.17,83.57 35.17,101.41 39.5,105.75 39.5,113.26 38.7,114.06 32.76,114.06 27.3,108.6 27.3,65.42
VDD_2V8 on BOTTOM: 20.09,13.29 20.09,18.81 16.51,18.81 15.49,17.79 15.49,13.29
VDD_CORE on TOP: 121.51,84.11 121.51,90.57 119.06,90.57 119.06,99.31 124.97,99.31 124.97,91.45 127.38,91.45 127.38,84.11
VDD_CORE on BOTTOM: 103.63,81.03 100.6,81.03 100.6,86.49 103.63,86.49
VDD_CORE on L05_PWR1: 111.3,83.76 107.44,79.9 107.44,76.98 106.52,76.06 93.82,76.06 93.38,75.62 92.84,75.62 92.84,76.25 92.64,76.45 91.85,76.45 91.69,76.3 91.69,75.62 91.06,75.62 91.06,76.34 92.08,77.36 92.08,78.88 91.82,79.14 90.42,79.14 90.04,78.75 90.04,77.36 89.79,77.1 89.03,77.1 88.9,77.23 88.9,77.99 87.76,79.14 87.76,85.1 90.64,87.99 97.95,87.99 98.46,88.5 107.24,97.55 125.42,97.55 127.64,95.34 127.64,85.23 126.36,83.96 122.95,83.96 119.26,87.64 112.39,87.64 111.3,86.55 ; 1 cut-out
VDD_DDR4 on TOP: 86.91,119.78 86.91,115.05 81.9,115.05 81.9,119.78
VDD_DDR4 on BOTTOM: 97.79,92.12 99.82,92.12 99.82,86.5 97.79,86.5
VDD_DDR4 on BOTTOM: 74.8,118.19 74.8,117.04 74.89,116.96 76.55,116.96 76.55,118.19
VDD_DDR4 on L06_PWR2: 91.06,81.93 91.06,80.02 91.44,79.64 93.6,79.64 94.36,80.41 96.26,80.41 98.17,80.28 104.01,86.12 104.01,105.99 90.89,119.12 76.42,119.12 75.4,118.11 75.4,101.91 87.5,89.81 87.5,85.49
VDD_DLL_MMC0 on BOTTOM: 115.82,70.5 115.82,75.58 113.18,75.58 113.18,71.63 112.62,71.07 112.62,70.5
VDD_MMC1 on TOP: 113.06,62.64 113.06,59.83 110.14,59.83 108.97,61.01 108.97,62.66 113.03,62.66
VDD_MMC1 on L03_SIG1: 103.96,73.07 103.96,72.63 106.1,70.5 106.1,67.25 108.64,64.71 108.64,62.22 109.29,61.56 111.63,61.56 111.63,68.09 106.65,73.07
VDD_MMC1 on L06_PWR2: 108.97,62.68 108.97,61.24 110.28,61.24 110.28,62.68
VDD_MMC1 on L06_PWR2: 39.6,22.27 39.6,19.65 42.32,19.65 42.32,22.27
VDDA1V8 on TOP: 126.24,63.58 126.24,67.06 126.25,67.07 130.94,67.07 130.94,61.96 130.93,61.96 130.93,61.01 132.62,59.33 134.36,59.33 135,58.69 135,57.55 132.72,57.55 132.33,57.16 130.43,57.16 130.43,59.39
VDDA1V8 on BOTTOM: 128.81,57.93 126.24,60.5 126.24,67.06 126.25,67.07 130.94,67.07 130.94,61.96 130.93,61.96 130.93,60.99 132.1,59.82 132.1,58.34 131.7,57.93
VDDA_1V8 on TOP: 109.22,68.09 109.22,69.99 111.12,69.99 111.12,77.87 111.89,77.87 112.27,78.25 112.27,80.66 108.71,80.66 108.71,83.58 109.47,83.58 109.47,85.1 112.01,85.1 112.01,82.69 113.86,80.84 113.86,68.09
VDDA_1V8 on TOP: 130.81,68.05 126.21,68.05 126.21,72.63 130.81,72.63
VDDA_1V8 on TOP: 90.3,58.31 90.3,55.01 91.69,55.01 91.69,58.31
VDDA_1V8 on BOTTOM: 130.82,68.05 126.21,68.05 126.21,73.06 130.82,73.06
VDDA_1V8 on BOTTOM: 110.72,71.13 112.14,71.13 112.14,68.47 111.89,68.21 108.71,68.21 108.58,68.34 108.58,69.86 108.84,70.12 110.72,70.12
VDDA_1V8 on BOTTOM: 108.05,80.51 108.05,83.59 110.59,83.59 110.62,83.57 110.62,81.38 109.74,80.51
VDDA_1V8 on BOTTOM: 91.47,62.37 91.47,58.99 94.31,58.99 94.31,62.37
